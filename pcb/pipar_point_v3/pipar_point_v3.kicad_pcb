# Repository RasmusKoit/pipar

File README.md:

# Pipar PCBs

ZMK firmware for the Pipar PCBs.

**Pipar** is a collection of different keyboards and keypads that I have designed. Each PCB in the series has unique features tailored to different needs and preferences.

More information about **Pipar Keyboards** here [https://pipar.koit.dev](https://pipar.koit.dev)

## User manual

The [user manual](docs/user-manual/README.md) explains which firmware to flash, the layers, Bluetooth, and how to type Estonian letters (õ ä ö ü š ž) on Windows, macOS and Linux. It also has printable Colemak-DH and QWERTY [cheatsheets](docs/user-manual/README.md#cheatsheets).

## Firmware

The Pipar keyboards run [ZMK](https://zmk.dev) firmware. Board definitions, custom drivers (LED indicators, caps-word events, a recovery watchdog), keymaps, and shields live in the [`zmk-keyboard-pipar`](https://github.com/RasmusKoit/zmk-keyboard-pipar) ZMK module — included here as the `zmk-keyboard-pipar` submodule.

Build firmware locally with the `build.sh` helper (requires Docker):

```bash
git clone --recurse-submodules https://github.com/RasmusKoit/pipar.git
cd pipar
./build.sh right   # Pipar Point central half (with trackpoint)
./build.sh left    # Pipar Point peripheral half
./build.sh all     # every target
```

Firmware is written to `.build/<target>/zephyr/zmk.uf2`. Builds can also be run through the [Build Pipar products](https://github.com/RasmusKoit/pipar/actions/workflows/build_pipar_products.yml) GitHub Actions workflow.

## Designed PCBs

PCB Files for each keyboard/project has been seperated into their own folders. The PCBs are designed in KiCad v9.x

Currently, the following PCBs are available:

- [Pipar & Sool](#pipar-ja-sool-pepper-and-salt) - 36-key split wireless keyboard with a 3x5+3 layout and a dongle.
- [Pipar Point](#pipar-point) - 40-key split wireless keyboard with a 3x5+3+2 layout, trackpoint and LEDs.
- [Pipar Flake](#pipar-flake) - 8+1 key wireless keypad with a rotary encoder and a screen.
- [Pipar Chip](#pipar-chip) - 12-key wireless keypad with Kailh PG1316S switches and LEDs.

### Pipar ja Sool (Pepper and Salt)

> [!TIP]
> Get your own Pipar & Sool from my [Etsy Store](https://piparkeyboards.etsy.com).

The **Pipar ja Sool** is a 36-key split wireless keyboard with a 3x5+3 layout with a dongle. It features:

- **Microcontrollers**: XIAO BLE for both halves and a dongle.
- **Switches**: Ambients Silent Kailh Low Profile Nocturnal Choc Switches.
- **Sockets**: Kailh Hotswap sockets for easy switch replacement.
- **Keymap**: Maintained in the [zmk-keyboard-pipar](https://github.com/RasmusKoit/zmk-keyboard-pipar) module.
- **LEDs**: White LEDs for backlight.

#### Pipar ja Sool Pictures

Pictures from version V1

<!-- markdownlint-disable MD033 -->
<details>
  <summary>More Pictures V3</summary>

</details>

#### Pipar ja Sool Design Details

> [!NOTE]
> The V3 design is compatible with the V2 case.

- **Layout**: Splayed split keyboard with a 3x5+3 layout.
  - **Thumb Cluster**: Three keys on each half.
  - **Outer Columns**: Split to reduce the distance to the keys.
- **Wireless**: Uses the XIAO BLE microcontroller for both halves and a dongle.
- **Battery**: Larger area for the battery to ensure longer usage time.
- **LEDs**: I sometimes miss the visual feedback of the LEDs, so I added them to the design.

Changenotes:

V3 version has went with the route of using smaller components with the 0403/SOD-323 package for resistors and diodes. The design is also compatible with the V2 case, so the case can be used with the V3 PCB.
V3 also has the added benefit of using solder nuts for mounting the PCB to the case, instead of just holes for M2 screws. This adds more possibilities for mounting the PCB to the case.

#### Pipar ja Sool V2 Order List

Consider supporting me by purchasing Pipar & Sool V3 Kit from my [Etsy Store](https://piparkeyboards.etsy.com).

The components list is for V2 version of the Pipar & Sool which uses larger components in 0805/SOD-123 package.
V3 version uses smaller components in 0403/SOD-323 package.

If you are interested in building the V2 version, here is a list of components you will need:

- **PCB**: 2x Pipar V2 PCBs [Gerber files here](./.extra/pipar_sool_v2.zip).
- **Microcontroller**: 3x [XIAO BLE microcontrollers (Aliexpress)](https://www.aliexpress.com/item/1005004459618789.html?spm=a2g0o.order_list.order_list_main.20.2f8718028ReplC)
- **On/Off Switch**: 2x [On/Off Switch (Aliexpress)](https://www.aliexpress.com/item/1005006710234187.html?spm=a2g0o.order_list.order_list_main.15.2f8718028ReplC)
- **Thread inserts**: 36x [M2 Thread Inserts (Aliexpress)](https://www.aliexpress.com/item/1005003582355741.html?spm=a2g0o.order_list.order_list_main.10.2f8718028ReplC)
- **Screws**: 10x [M2x4mm Screws (Aliexpress)](https://www.aliexpress.com/item/1005005070119421.html?spm=a2g0o.order_list.order_list_main.5.2f8718028ReplC)
- **Switches**: 36x [Ambients Silent Kailh Low Profile Nocturnal Choc Switches (SplitKB)](https://splitkb.com/products/ambients-kailh-low-profile-choc-switches?variant=48116119830875)
- **Sockets**: 36x [Kailh Hotswap sockets (SplitKB)](https://splitkb.com/products/kailh-hotswap-sockets?variant=39472161456205)
- **Diodes**: 36x [1N4148/SOD-123 Diodes (SplitKB)](https://splitkb.com/products/smd-diodes?variant=42283984027907)
- **Battery**: 2x [320mAh 3x30x40mm (Oomipood)](https://www.oomipood.ee/product/accu_lp303040_cl). Case is designed for 3mm height batteries with some extra space.
- **Case**: 1x [Pipar Case V2](https://cad.onshape.com/documents/0618546ffe3fe295af383a46/w/2cb3b1882647ac70cde86ee4/e/379ba082d1ffd285c3cab9c2)
- **Keycaps**: 1x [Kailh Choc Keycaps **Colemak-DH** (FKCaps)](https://fkcaps.com/custom/KYTMMA)

### Pipar Point

> [!NOTE]
> I am happy to announce that for the Pipar Point project, I have partnered with [PCBWay](https://www.pcbway.com/) to provide the PCBs for the project. PCBWay is a professional PCB manufacturer with over 10 years of experience in the industry. They offer a wide range of services, including PCB manufacturing, PCB assembly, and PCB design. I am excited to be working with PCBWay on this project, and I am confident that they will deliver high-quality PCBs that meet my specifications.

*Current PCB revision: v3.1*
*In regular use — firmware actively maintained.*

#### Pipar Point Pictures

<!-- markdownlint-disable MD033 -->
<details>
  <summary>More Pictures</summary>

</details>

#### Pipar Point Design Details

- **Layout**: Splayed split keyboard with a 3x5+3+2  layout.
  - **Thumb Cluster**: Three keys on each half.
  - **Pinkie Cluster**: Split to reduce the distance to the keys. Extra Keys for macros or foreign letters
- **Wireless**: Uses ISP1807 SIP IC based on NRF52840 IC for both halves.
- **Battery**: Larger area for the battery to ensure longer usage time.
- **Trackpoint**: Sprintek Trackpoint for mouse control on the right side.
- **LEDs**: I sometimes miss the visual feedback of the LEDs, so I added them to the design.
- **Top Plate**: Designed to be used with a top plate for a more rigid build.
- **Mounting**: Case includes magsafe mounting for easy attachment and detachment. Rubber feet to keep the keyboard in place.

Idea was to iterate on the Pipar ja Sool design and add a trackpoint for mouse control. The design is still in the early stages and will be updated as the project progresses. Because of the trackpoint, LEDs and the battery size has been increased to 2500mAh to compensate for the power draw of the trackpoint and LEDs. With this design, I am aiming to challege myself to design a more complex PCB by using more components which will also be smaller in size. The design will also include a top plate to make the build more rigid and also to hide the trackpoint mounting cleaner.

I want to thank [zhiayang/Mikoto](https://github.com/zhiayang/mikoto) and [Hello9999901/laptop](https://github.com/Hello9999901/laptop/tree/main/keyboard) for making this project possible. Thank you [Eden](https://github.com/galaxyeden) for helping me understand more about Zephyr and getting me started.

### Pipar Chip

Pipar Chip is a 12-key wireless keypad with Kailh PG1316S switches and LEDs.

Pipar Chip features:

- **Onboard Components**: Features ISP1807 SIP IC based on NRF52840 IC
- **Switches**: Kailh PG1316S switches.
- **LEDs**: White LEDs for backlighting. 2 LEDs for charging and error indication. 3 extra LEDs that can be used for any purpose.
- **Components**: Uses smaller components in 0603/SOD-523 package for resistors, capacitors, etc.
- **Battery**: 500mAh battery to ensure longer usage time even with the LEDs.

#### Pipar Chip Pictures

### Pipar Flake

The **Pipar Flake** is an 8+1 key wireless keypad with a rotary encoder (optional) and a screen. It includes:

- **Microcontroller**: pro_micro-pinout nRF52840 board (e.g. SuperMini nRF52840 or nice!nano).
- **Display**: Tiny OLED display.
- **Switches**: Ambients Silent Kailh Low Profile Nocturnal Choc Switches.
- **Sockets**: Kailh Hotswap sockets for easy switch replacement.
- **LEDs**: White LEDs for backlighting.

#### Pipar Flake Pictures

#### Pipar Flake Design Details

- **Usage**: Intended as a tiny keypad or numpad.
  - **Current Use Case**: Control media player (e.g., Kodi).
- **Size**: Designed to be as small as possible while still being usable.
- **Rotary Encoder**:  
  - **Function**: Can control volume.
  - **Push Button**: Can be used to change layers.

## License

- **Hardware** (`pcb/`, `build_guides/`): [CERN-OHL-S-2.0](LICENSE).
  You can make, change and sell these boards. If you ship a modified version,
  publish its full design under the same licence.
- **Firmware, config and scripts** (`config/`, `tests/`, `build.sh`):
  [MIT](LICENSE-FIRMWARE), the same licence as ZMK. The ZMK module in
  `zmk-keyboard-pipar` is MIT too.

Third-party parts keep their own licences: the footprint libraries included as
submodules, vendor footprints and 3D models in `pcb/Footprints-Symbols`, and
any file with its own `SPDX-License-Identifier` header.

## KiCad design pcb/pipar_point_v3/pipar_point_v3.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 100nF; C_0603_1608Metric; Mouser Part Number 603-CC603KRX7R8BB104
FID1, FID2, FID3, FID4: Fiducial; Fiducial_0.5mm_Mask1mm
H1, H2, H3: PanelMountingHole; MountingHole_3mm
H4, H5: Art; Salt
R1, R2, R3: 10k; R_0603_1608Metric; Manufacturer_Part_Number CRCW060310K0FKEA; Mouser Part Number 71-CRCW0603-10K-E3
SW1, SW2: SW_SPDT; SW_SPDT_PCM12; Manufacturer_Part_Number PCM12SMTBR; Mouser Part Number 611-PCM12SMTBR
U1: SK8707-01-0C Sensor
U2: SK8707-01

Connections:
/Side-Left/BAT_ON: SW1.2 (B); also elsewhere on the board
/Side-Left/Power/VBAT: SW1.3 (C); also elsewhere on the board
/Side-Right/3.3V: R2.2, R3.2, U2.5A (VCC); also elsewhere on the board
/Side-Right/BAT_ON: SW2.2 (B); also elsewhere on the board
/Side-Right/Power/VBAT: SW2.1 (A); also elsewhere on the board
/Side-Right/TPClock: R2.1, U2.3A (IPD_CLK); also elsewhere on the board
/Side-Right/TPData: R3.1, U2.2A (IPD_DATA); also elsewhere on the board
/Side-Right/TPRST: C5.2, R1.1, U2.4A (IPD_RST); also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.1, C5.1, R1.2, U2.1A (GND), U2.7C (GND); also elsewhere on the board
unnamed: C1.2, U1.4D, U2.4D
unnamed: C2.2, U1.3D, U2.3D
unnamed: C3.2, U1.2D, U2.2D
unnamed: C4.2, U1.1D, U2.1D

Parts:
D29: LED_Blue; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5B; Mouser Part Number 743-S63AT5B
D30: LED_Green; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5G; Mouser Part Number 743-IN-S63AT5G
H48, H49, H50, H51, H53, H74, H75, H76: MountingHole; MountingHole_2.2mm_M2
H52: Art-small; Salt-8x8
J7: Conn_02x03_Odd_Even; PinHeader_2x03_P2.00mm_Vertical_DEBUG
J10, J11: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical
R39, R40: 1.5k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-071K5L; Mouser Part Number 603-RC0603FR-071K5L
SW5: EVP-BB1AAB000; EVPBB2A9B000; Mouser Part Number 667-EVP-BB1AAB000
TP5: TestPoint_Probe; TestPoint_Pad_D1.0mm
U9: ISP1807-LR-RS; Manufacturer_Part_Number ISP1807-LR-RS; Mouser Part Number 359-ISP1807-LR-RS

Connections:
/Dongle/3.3V: J7.1, J11.9, R39.1, R40.1, U9.26 (VCC_NRF); also elsewhere on the board
/Dongle/BAT_SCL: J10.9, U9.32 (P0_08); also elsewhere on the board
/Dongle/BAT_SDA: J10.10, U9.34 (P0_06); also elsewhere on the board
/Dongle/Backlight: J11.8, U9.61 (P1_11)
/Dongle/Col0: J10.2, U9.48 (P0_28_AIN4)
/Dongle/Col1: J10.3, U9.46 (P0_29_AIN5)
/Dongle/Col2: J10.4, U9.44 (P0_30_AIN6)
/Dongle/Col3: J10.5, U9.42 (P0_31_AIN7)
/Dongle/Col4: J10.6, U9.40 (P0_02_AIN0)
/Dongle/Col5: J10.7, U9.38 (P0_03_AIN1)
/Dongle/Col6: J10.8, U9.36 (P0_05_AIN3)
/Dongle/LED_1: D29.1 (K), U9.52 (P1_14)
/Dongle/LED_2: D30.1 (K), U9.59 (P1_12)
/Dongle/RESET: J7.6, SW5.1 (NO_1), SW5.2 (NO_2), U9.13 (P0_18_RESET)
/Dongle/Row0: J11.2, U9.56 (P1_09_TRACEDATA3)
/Dongle/Row1: J11.3, U9.63 (P1_04)
/Dongle/Row2: J11.4, U9.54 (P1_05)
/Dongle/SWDCLK: J7.4, U9.30 (SWDCLK)
/Dongle/SWDIO: J7.2, U9.28 (SWDIO)
/Dongle/TPClock: J11.7, U9.5 (P0_14)
/Dongle/TPData: J11.6, U9.3 (P0_12_TRACEDATA1)
/Dongle/TPRST: J11.5, U9.2 (P0_09_NFC1)
/Dongle/USB_D+: U9.8 (D+); also elsewhere on the board
/Dongle/USB_D-: U9.10 (D-); also elsewhere on the board
/Dongle/VBUS: U9.12 (VBUS); also elsewhere on the board
/Dongle/VSYS: J11.10; also elsewhere on the board
GND: J7.3, J7.5, J10.1, J11.1, SW5.3 (COM_1), SW5.4 (COM_2), TP5.1, U9.1 (VSS), U9.7 (VSS), U9.14 (VSS), U9.16 (VSS), U9.18 (VSS), U9.21 (VSS), U9.23 (VSS), U9.24 (VSS), U9.25 (VSS), U9.31 (VSS); also elsewhere on the board
unnamed: D29.2 (A), R39.2
unnamed: D30.2 (A), R40.2
unnamed: U9.20 (OUT_ANT), U9.22 (OUT_MOD)

Notes on the sheet:
V_{f} < 3.0V
Status LED

Parts:
D1: LED_Blue; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5B; Mouser Part Number 743-S63AT5B
D2: LED_Green; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5G; Mouser Part Number 743-IN-S63AT5G
H6: Art-small; Salt-smallest
H7, H8, H9, H10, H11: MouseBite; mouse-bite-3mm-6mm
H12, H13, H14, H15, H16: MountingHole; MountingHole_2.2mm_M2
J1: Conn_02x03_Odd_Even; PinHeader_2x03_P2.00mm_Vertical_DEBUG
R4, R5: 1.5k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-071K5L; Mouser Part Number 603-RC0603FR-071K5L
SW3: EVP-BB1AAB000; EVPBB2A9B000; Mouser Part Number 667-EVP-BB1AAB000
TP1: TestPoint_Probe; TestPoint_Pad_D1.0mm
U3: ISP1807-LR-RS; Manufacturer_Part_Number ISP1807-LR-RS; Mouser Part Number 359-ISP1807-LR-RS

Connections:
/Side-Left/3.3V: J1.1, R4.1, R5.1, U3.26 (VCC_NRF); also elsewhere on the board
/Side-Left/BAT_SCL: U3.34 (P0_06); also elsewhere on the board
/Side-Left/BAT_SDA: U3.32 (P0_08); also elsewhere on the board
/Side-Left/Backlight: U3.61 (P1_11); also elsewhere on the board
/Side-Left/Col0: U3.48 (P0_28_AIN4); also elsewhere on the board
/Side-Left/Col1: U3.46 (P0_29_AIN5); also elsewhere on the board
/Side-Left/Col2: U3.44 (P0_30_AIN6); also elsewhere on the board
/Side-Left/Col3: U3.42 (P0_31_AIN7); also elsewhere on the board
/Side-Left/Col4: U3.40 (P0_02_AIN0); also elsewhere on the board
/Side-Left/Col5: U3.38 (P0_03_AIN1); also elsewhere on the board
/Side-Left/Col6: U3.36 (P0_05_AIN3); also elsewhere on the board
/Side-Left/LED_1: D1.1 (K), U3.52 (P1_14)
/Side-Left/LED_2: D2.1 (K), U3.59 (P1_12)
/Side-Left/RESET: J1.6, SW3.1 (NO_1), SW3.2 (NO_2), U3.13 (P0_18_RESET)
/Side-Left/Row0: U3.56 (P1_09_TRACEDATA3); also elsewhere on the board
/Side-Left/Row1: U3.63 (P1_04); also elsewhere on the board
/Side-Left/Row2: U3.54 (P1_05); also elsewhere on the board
/Side-Left/SWDCLK: J1.4, U3.30 (SWDCLK)
/Side-Left/SWDIO: J1.2, U3.28 (SWDIO)
/Side-Left/USB_D+: U3.8 (D+); also elsewhere on the board
/Side-Left/USB_D-: U3.10 (D-); also elsewhere on the board
/Side-Left/VBUS: U3.12 (VBUS); also elsewhere on the board
GND: J1.3, J1.5, SW3.3 (COM_1), SW3.4 (COM_2), TP1.1, U3.1 (VSS), U3.7 (VSS), U3.14 (VSS), U3.16 (VSS), U3.18 (VSS), U3.21 (VSS), U3.23 (VSS), U3.24 (VSS), U3.25 (VSS), U3.31 (VSS); also elsewhere on the board
unnamed: D1.2 (A), R4.2
unnamed: D2.2 (A), R5.2
unnamed: U3.20 (OUT_ANT), U3.22 (OUT_MOD)

Parts of its further copies:
D3: LED_Blue; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5B; Mouser Part Number 743-S63AT5B
D4: LED_Green; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5G; Mouser Part Number 743-IN-S63AT5G
H17: Art-small; Salt-smallest
H18, H19, H20, H21, H22: MouseBite; mouse-bite-3mm-6mm
H23, H24, H25, H26, H27: MountingHole; MountingHole_2.2mm_M2
J2: Conn_02x03_Odd_Even; PinHeader_2x03_P2.00mm_Vertical_DEBUG
R6, R7: 1.5k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-071K5L; Mouser Part Number 603-RC0603FR-071K5L
SW4: EVP-BB1AAB000; EVPBB2A9B000; Mouser Part Number 667-EVP-BB1AAB000
TP2: TestPoint_Probe; TestPoint_Pad_D1.0mm
U4: ISP1807-LR-RS; Manufacturer_Part_Number ISP1807-LR-RS; Mouser Part Number 359-ISP1807-LR-RS

Connections of its further copies:
/Side-Right/3.3V: J2.1, R6.1, R7.1, U4.26 (VCC_NRF); also elsewhere on the board
/Side-Right/BAT_SCL: U4.34 (P0_06); also elsewhere on the board
/Side-Right/BAT_SDA: U4.32 (P0_08); also elsewhere on the board
/Side-Right/Backlight: U4.61 (P1_11); also elsewhere on the board
/Side-Right/Col0: U4.48 (P0_28_AIN4); also elsewhere on the board
/Side-Right/Col1: U4.46 (P0_29_AIN5); also elsewhere on the board
/Side-Right/Col2: U4.44 (P0_30_AIN6); also elsewhere on the board
/Side-Right/Col3: U4.42 (P0_31_AIN7); also elsewhere on the board
/Side-Right/Col4: U4.40 (P0_02_AIN0); also elsewhere on the board
/Side-Right/Col5: U4.38 (P0_03_AIN1); also elsewhere on the board
/Side-Right/Col6: U4.36 (P0_05_AIN3); also elsewhere on the board
/Side-Right/LED_1: D3.1 (K), U4.52 (P1_14)
/Side-Right/LED_2: D4.1 (K), U4.59 (P1_12)
/Side-Right/RESET: J2.6, SW4.1 (NO_1), SW4.2 (NO_2), U4.13 (P0_18_RESET)
/Side-Right/Row0: U4.56 (P1_09_TRACEDATA3); also elsewhere on the board
/Side-Right/Row1: U4.63 (P1_04); also elsewhere on the board
/Side-Right/Row2: U4.54 (P1_05); also elsewhere on the board
/Side-Right/SWDCLK: J2.4, U4.30 (SWDCLK)
/Side-Right/SWDIO: J2.2, U4.28 (SWDIO)
/Side-Right/TPClock: U4.5 (P0_14); also elsewhere on the board
/Side-Right/TPData: U4.3 (P0_12_TRACEDATA1); also elsewhere on the board
/Side-Right/TPRST: U4.2 (P0_09_NFC1); also elsewhere on the board
/Side-Right/USB_D+: U4.8 (D+); also elsewhere on the board
/Side-Right/USB_D-: U4.10 (D-); also elsewhere on the board
/Side-Right/VBUS: U4.12 (VBUS); also elsewhere on the board
GND: J2.3, J2.5, SW4.3 (COM_1), SW4.4 (COM_2), TP2.1, U4.1 (VSS), U4.7 (VSS), U4.14 (VSS), U4.16 (VSS), U4.18 (VSS), U4.21 (VSS), U4.23 (VSS), U4.24 (VSS), U4.25 (VSS), U4.31 (VSS); also elsewhere on the board
unnamed: D3.2 (A), R6.2
unnamed: D4.2 (A), R7.2
unnamed: U4.20 (OUT_ANT), U4.22 (OUT_MOD)

Notes on the sheet:
V_{f} < 3.0V
Status LED

Parts:
C6: 10nF; C_0603_1608Metric; Mouser Part Number 810-CGA3E2X7R1H103K
C7, C8, C12: 1uF; C_0603_1608Metric; Mouser Part Number 963-LMK107B7105KA-T
C9: 100nF; C_0603_1608Metric; Mouser Part Number 603-CC603KRX7R8BB104
C10, C11, C14: 10uF; C_0603_1608Metric; Mouser Part Number 81-GRM188R61E106KA3D
C13: 2.2uF; C_0603_1608Metric; Mouser Part Number 963-EMK107BB7225KA-T
D25: LED_Error; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5A; Mouser Part Number 743-IN-S63AT5A
D26: LED_Green; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5G; Mouser Part Number 743-IN-S63AT5G
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; Mouser Part Number 179-UJ20CHGSMTP16TR
J4: Conn_JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizo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; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal; Manufacturer_Part_Number S2B-PH-SM4-TB(LF)(SN); Mouser Part Number 306-S2BPHSM4TBLFSN
L1: 2.2uH; L_0805_2012Metric; Manufacturer_Part_Number MLZ2012A2R2WT000; Mouser Part Number 810-MLZ2012A2R2WT000
NT1: NetTie_2; NetTie-2_THT_Pad0.3mm
R29, R30: 10k; R_0603_1608Metric; Manufacturer_Part_Number CRCW060310K0FKEA; Mouser Part Number 71-CRCW0603-10K-E3
R31, R32: 1.5k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-071K5L; Mouser Part Number 603-RC0603FR-071K5L
R33: 500k; R_0603_1608Metric; Manufacturer_Part_Number CRCW0603499KFKEA; Mouser Part Number 71-CRCW0603-499K-E3
TP3: TestPoint_Probe; TestPoint_Pad_D1.0mm
U5: ESDR0502NMUTAG; UDFN-6_1.2x1.0mm_P0.4mm; Manufacturer Part ESDR0502NMUTBG; LCSC C327480
U6: nPM1300-QEXX; QFN-32-1EP_5x5mm_P0.5mm_EP3.6x3.6mm_ThermalVias; Manufacturer_Part_Number nPM1300-QEAA-R7; Mouser Part Number 949-NPM1300-QEAA-R7

Connections:
/Dongle/3.3V: C9.2, C14.2, L1.1, R29.1, R30.1, U6.12 (VDDIO), U6.32 (VOUT2); also elsewhere on the board
/Dongle/BAT_SCL: R30.2, U6.14 (SCL); also elsewhere on the board
/Dongle/BAT_SDA: R29.2, U6.13 (SDA); also elsewhere on the board
/Dongle/Power/CC1: J3.A5 (CC1), U6.23 (CC1)
/Dongle/Power/CC2: J3.B5 (CC2), U6.24 (CC2)
/Dongle/Power/PVSS2: C10.1, C14.1, NT1.1, U6.6 (PVSS2)
/Dongle/Power/VBAT: C13.1, J4.2, U6.19 (VBAT)
/Dongle/Power/VBUS: C7.1, C8.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), U5.6 (VBUS), U6.21 (VBUS)
/Dongle/USB_D+: J3.A6 (D+), J3.B6 (D+), U5.2 (NC), U5.5 (D+); also elsewhere on the board
/Dongle/USB_D-: J3.A7 (D-), J3.B7 (D-), U5.3 (NC), U5.4 (D-); also elsewhere on the board
/Dongle/VBUS: C12.1, TP3.1, U6.22 (VBUSOUT); also elsewhere on the board
/Dongle/VSYS: C10.2, C11.2, R31.2, R32.2, U6.1 (VOUT1), U6.4 (PVDD), U6.20 (VSYS); also elsewhere on the board
GND: C6.2, C7.2, C8.2, C9.1, C11.1, C12.2, C13.2, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J4.1, J4.MP, NT1.2, R33.2, U5.1 (GND), U6.2 (PVSS1), U6.17 (VSET1), U6.18 (NTC), U6.28 (LSIN1/VINLDO1), U6.29 (LSOUT1/VOUTLDO1), U6.30 (LSIN2/VINLDO2), U6.31 (LSOUT2/VOUTLDO2), U6.33 (AVSS); also elsewhere on the board
unnamed: D25.2 (A), R31.1
unnamed: D25.1 (K), U6.25 (LED0)
unnamed: D26.2 (A), R32.1
unnamed: D26.1 (K), U6.26 (LED1)
unnamed: C6.1, J3.S1 (SHIELD)
unnamed: L1.2, U6.5 (SW2)
unnamed: R33.1, U6.16 (VSET2)

Parts of its further copies:
C15, C24: 10nF; C_0603_1608Metric; Mouser Part Number 810-CGA3E2X7R1H103K
C16, C17, C21, C25, C26, C30: 1uF; C_0603_1608Metric; Mouser Part Number 963-LMK107B7105KA-T
C18, C27: 100nF; C_0603_1608Metric; Mouser Part Number 603-CC603KRX7R8BB104
C19, C20, C23, C28, C29, C32: 10uF; C_0603_1608Metric; Mouser Part Number 81-GRM188R61E106KA3D
C22, C31: 2.2uF; C_0603_1608Metric; Mouser Part Number 963-EMK107BB7225KA-T
D27, D31: LED_Error; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5A; Mouser Part Number 743-IN-S63AT5A
D28, D32: LED_Green; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5G; Mouser Part Number 743-IN-S63AT5G
J5, J8: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; Mouser Part Number 179-UJ20CHGSMTP16TR
J6, J9: Conn_JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizo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; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal; Manufacturer_Part_Number S2B-PH-SM4-TB(LF)(SN); Mouser Part Number 306-S2BPHSM4TBLFSN
L2, L3: 2.2uH; L_0805_2012Metric; Manufacturer_Part_Number MLZ2012A2R2WT000; Mouser Part Number 810-MLZ2012A2R2WT000
NT2, NT3: NetTie_2; NetTie-2_THT_Pad0.3mm
R34, R35, R41, R42: 10k; R_0603_1608Metric; Manufacturer_Part_Number CRCW060310K0FKEA; Mouser Part Number 71-CRCW0603-10K-E3
R36, R37, R43, R44: 1.5k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-071K5L; Mouser Part Number 603-RC0603FR-071K5L
R38, R45: 500k; R_0603_1608Metric; Manufacturer_Part_Number CRCW0603499KFKEA; Mouser Part Number 71-CRCW0603-499K-E3
TP4, TP6: TestPoint_Probe; TestPoint_Pad_D1.0mm
U7, U10: ESDR0502NMUTAG; UDFN-6_1.2x1.0mm_P0.4mm; Manufacturer Part ESDR0502NMUTBG; LCSC C327480
U8, U11: nPM1300-QEXX; QFN-32-1EP_5x5mm_P0.5mm_EP3.6x3.6mm_ThermalVias; Manufacturer_Part_Number nPM1300-QEAA-R7; Mouser Part Number 949-NPM1300-QEAA-R7

Connections of its further copies:
/Side-Left/3.3V: C18.2, C23.2, L2.1, R34.1, R35.1, U8.12 (VDDIO), U8.32 (VOUT2); also elsewhere on the board
/Side-Left/BAT_ON: J6.2; also elsewhere on the board
/Side-Left/BAT_SCL: R35.2, U8.14 (SCL); also elsewhere on the board
/Side-Left/BAT_SDA: R34.2, U8.13 (SDA); also elsewhere on the board
/Side-Left/Power/CC1: J5.A5 (CC1), U8.23 (CC1)
/Side-Left/Power/CC2: J5.B5 (CC2), U8.24 (CC2)
/Side-Left/Power/PVSS2: C19.1, C23.1, NT2.1, U8.6 (PVSS2)
/Side-Left/Power/VBAT: C22.1, U8.19 (VBAT); also elsewhere on the board
/Side-Left/Power/VBUS: C16.1, C17.1, J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), U7.6 (VBUS), U8.21 (VBUS)
/Side-Left/Power/VSYS: C19.2, C20.2, R36.2, R37.2, U8.1 (VOUT1), U8.4 (PVDD), U8.20 (VSYS)
/Side-Left/USB_D+: J5.A6 (D+), J5.B6 (D+), U7.2 (NC), U7.5 (D+); also elsewhere on the board
/Side-Left/USB_D-: J5.A7 (D-), J5.B7 (D-), U7.3 (NC), U7.4 (D-); also elsewhere on the board
/Side-Left/VBUS: C21.1, TP4.1, U8.22 (VBUSOUT); also elsewhere on the board
/Side-Right/3.3V: C27.2, C32.2, L3.1, R41.1, R42.1, U11.12 (VDDIO), U11.32 (VOUT2); also elsewhere on the board
/Side-Right/BAT_ON: J9.2; also elsewhere on the board
/Side-Right/BAT_SCL: R42.2, U11.14 (SCL); also elsewhere on the board
/Side-Right/BAT_SDA: R41.2, U11.13 (SDA); also elsewhere on the board
/Side-Right/Power/CC1: J8.A5 (CC1), U11.23 (CC1)
/Side-Right/Power/CC2: J8.B5 (CC2), U11.24 (CC2)
/Side-Right/Power/PVSS2: C28.1, C32.1, NT3.1, U11.6 (PVSS2)
/Side-Right/Power/VBAT: C31.1, U11.19 (VBAT); also elsewhere on the board
/Side-Right/Power/VBUS: C25.1, C26.1, J8.A4 (VBUS), J8.A9 (VBUS), J8.B4 (VBUS), J8.B9 (VBUS), U10.6 (VBUS), U11.21 (VBUS)
/Side-Right/Power/VSYS: C28.2, C29.2, R43.2, R44.2, U11.1 (VOUT1), U11.4 (PVDD), U11.20 (VSYS)
/Side-Right/USB_D+: J8.A6 (D+), J8.B6 (D+), U10.2 (NC), U10.5 (D+); also elsewhere on the board
/Side-Right/USB_D-: J8.A7 (D-), J8.B7 (D-), U10.3 (NC), U10.4 (D-); also elsewhere on the board
/Side-Right/VBUS: C30.1, TP6.1, U11.22 (VBUSOUT); also elsewhere on the board
GND: C15.2, C16.2, C17.2, C18.1, C20.1, C21.2, C22.2, C24.2, C25.2, C26.2, C27.1, C29.1, C30.2, C31.2, J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J6.1, J6.MP, J8.A1 (GND), J8.A12 (GND), J8.B1 (GND), J8.B12 (GND), J9.1, J9.MP, NT2.2, NT3.2, R38.2, R45.2, U7.1 (GND), U8.2 (PVSS1), U8.17 (VSET1), U8.18 (NTC), U8.28 (LSIN1/VINLDO1), U8.29 (LSOUT1/VOUTLDO1), U8.30 (LSIN2/VINLDO2), U8.31 (LSOUT2/VOUTLDO2), U8.33 (AVSS), U10.1 (GND), U11.2 (PVSS1), U11.17 (VSET1), U11.18 (NTC), U11.28 (LSIN1/VINLDO1), U11.29 (LSOUT1/VOUTLDO1), U11.30 (LSIN2/VINLDO2), U11.31 (LSOUT2/VOUTLDO2), U11.33 (AVSS); also elsewhere on the board
unnamed: D27.2 (A), R36.1
unnamed: D27.1 (K), U8.25 (LED0)
unnamed: D28.2 (A), R37.1
unnamed: D28.1 (K), U8.26 (LED1)
unnamed: D31.2 (A), R43.1
unnamed: D31.1 (K), U11.25 (LED0)
unnamed: D32.2 (A), R44.1
unnamed: D32.1 (K), U11.26 (LED1)
unnamed: C15.1, J5.S1 (SHIELD)
unnamed: C24.1, J8.S1 (SHIELD)
unnamed: L2.2, U8.5 (SW2)
unnamed: R38.1, U8.16 (VSET2)
unnamed: L3.2, U11.5 (SW2)
unnamed: R45.1, U11.16 (VSET2)

Notes on the sheet:
BMIC + Power
VIA to GND
USB Connector + ESD
