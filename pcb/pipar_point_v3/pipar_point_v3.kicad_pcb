# Repository RasmusKoit/pipar (continued)

## KiCad design pcb/pipar_sool/pipar_sool.kicad_pcb (continued)

Parts:
CH1, CH2, CH3, CH4, CH5, CH6, CH7, CH8, CH9, CH10, CH11, CH12, CH13, CH14, CH15, CH16, CH17, CH18: KSwitch; Kailh_HS_Socket
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18: D; D_0402_1005Metric
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18: LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18: 100; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder

Connections:
3V3: LED1.2 (A), LED2.2 (A), LED3.2 (A), LED4.2 (A), LED5.2 (A), LED6.2 (A), LED7.2 (A), LED8.2 (A), LED9.2 (A), LED10.2 (A), LED11.2 (A), LED12.2 (A), LED13.2 (A), LED14.2 (A), LED15.2 (A), LED16.2 (A), LED17.2 (A), LED18.2 (A); also elsewhere on the board
COL0: CH1.1, CH2.1, CH3.1; also elsewhere on the board
COL1: CH4.1, CH5.1, CH6.1; also elsewhere on the board
COL2: CH7.1, CH8.1, CH9.1; also elsewhere on the board
COL3: CH10.1, CH11.1, CH12.1; also elsewhere on the board
COL4: CH13.1, CH14.1, CH15.1; also elsewhere on the board
COL5: CH16.1, CH17.1, CH18.1; also elsewhere on the board
LEDOut: R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2; also elsewhere on the board
unnamed: CH1.2, D1.2 (A)
unnamed: CH2.2, D2.2 (A)
unnamed: CH3.2, D3.2 (A)
unnamed: CH4.2, D4.2 (A)
unnamed: CH5.2, D5.2 (A)
unnamed: CH6.2, D6.2 (A)
unnamed: CH7.2, D7.2 (A)
unnamed: CH8.2, D8.2 (A)
unnamed: CH9.2, D9.2 (A)
unnamed: CH10.2, D10.2 (A)
unnamed: CH11.2, D11.2 (A)
unnamed: CH12.2, D12.2 (A)
unnamed: CH13.2, D13.2 (A)
unnamed: CH14.2, D14.2 (A)
unnamed: CH15.2, D15.2 (A)
unnamed: CH16.2, D16.2 (A)
unnamed: CH17.2, D17.2 (A)
unnamed: CH18.2, D18.2 (A)
unnamed: LED1.1 (K), R1.1
unnamed: LED2.1 (K), R2.1
unnamed: LED3.1 (K), R3.1
unnamed: LED4.1 (K), R4.1
unnamed: LED5.1 (K), R5.1
unnamed: LED6.1 (K), R6.1
unnamed: LED7.1 (K), R7.1
unnamed: LED8.1 (K), R8.1
unnamed: LED9.1 (K), R9.1
unnamed: LED10.1 (K), R10.1
unnamed: LED11.1 (K), R11.1
unnamed: LED12.1 (K), R12.1
unnamed: LED13.1 (K), R13.1
unnamed: LED14.1 (K), R14.1
unnamed: LED15.1 (K), R15.1
unnamed: LED16.1 (K), R16.1
unnamed: LED17.1 (K), R17.1
unnamed: LED18.1 (K), R18.1
ROW0: D1.1 (K), D4.1 (K), D7.1 (K), D10.1 (K), D13.1 (K), D16.1 (K); also elsewhere on the board
ROW1: D2.1 (K), D5.1 (K), D8.1 (K), D11.1 (K), D14.1 (K), D17.1 (K); also elsewhere on the board
ROW2: D3.1 (K), D6.1 (K), D9.1 (K), D12.1 (K), D15.1 (K), D18.1 (K); also elsewhere on the board

Parts of its further copies:
CH19, CH20, CH21, CH22, CH23, CH24, CH25, CH26, CH27, CH28, CH29, CH30, CH31, CH32, CH33, CH34, CH35, CH36: KSwitch; Kailh_HS_Socket
D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36: D; D_0402_1005Metric
LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36: LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36: 100; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder

Connections of its further copies:
3V3: LED19.2 (A), LED20.2 (A), LED21.2 (A), LED22.2 (A), LED23.2 (A), LED24.2 (A), LED25.2 (A), LED26.2 (A), LED27.2 (A), LED28.2 (A), LED29.2 (A), LED30.2 (A), LED31.2 (A), LED32.2 (A), LED33.2 (A), LED34.2 (A), LED35.2 (A), LED36.2 (A); also elsewhere on the board
COL0: CH19.1, CH20.1, CH21.1; also elsewhere on the board
COL1: CH22.1, CH23.1, CH24.1; also elsewhere on the board
COL2: CH25.1, CH26.1, CH27.1; also elsewhere on the board
COL3: CH28.1, CH29.1, CH30.1; also elsewhere on the board
COL4: CH31.1, CH32.1, CH33.1; also elsewhere on the board
COL5: CH34.1, CH35.1, CH36.1; also elsewhere on the board
LEDOut: R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2; also elsewhere on the board
unnamed: CH19.2, D19.2 (A)
unnamed: CH20.2, D20.2 (A)
unnamed: CH21.2, D21.2 (A)
unnamed: CH22.2, D22.2 (A)
unnamed: CH23.2, D23.2 (A)
unnamed: CH24.2, D24.2 (A)
unnamed: CH25.2, D25.2 (A)
unnamed: CH26.2, D26.2 (A)
unnamed: CH27.2, D27.2 (A)
unnamed: CH28.2, D28.2 (A)
unnamed: CH29.2, D29.2 (A)
unnamed: CH30.2, D30.2 (A)
unnamed: CH31.2, D31.2 (A)
unnamed: CH32.2, D32.2 (A)
unnamed: CH33.2, D33.2 (A)
unnamed: CH34.2, D34.2 (A)
unnamed: CH35.2, D35.2 (A)
unnamed: CH36.2, D36.2 (A)
unnamed: LED19.1 (K), R19.1
unnamed: LED20.1 (K), R20.1
unnamed: LED21.1 (K), R21.1
unnamed: LED22.1 (K), R22.1
unnamed: LED23.1 (K), R23.1
unnamed: LED24.1 (K), R24.1
unnamed: LED25.1 (K), R25.1
unnamed: LED26.1 (K), R26.1
unnamed: LED27.1 (K), R27.1
unnamed: LED28.1 (K), R28.1
unnamed: LED29.1 (K), R29.1
unnamed: LED30.1 (K), R30.1
unnamed: LED31.1 (K), R31.1
unnamed: LED32.1 (K), R32.1
unnamed: LED33.1 (K), R33.1
unnamed: LED34.1 (K), R34.1
unnamed: LED35.1 (K), R35.1
unnamed: LED36.1 (K), R36.1
ROW0: D19.1 (K), D22.1 (K), D25.1 (K), D28.1 (K), D31.1 (K), D34.1 (K); also elsewhere on the board
ROW1: D20.1 (K), D23.1 (K), D26.1 (K), D29.1 (K), D32.1 (K), D35.1 (K); also elsewhere on the board
ROW2: D21.1 (K), D24.1 (K), D27.1 (K), D30.1 (K), D33.1 (K), D36.1 (K); also elsewhere on the board

Board: 2 copper layers, 142.4 x 110.5 mm, 187 parts (81 on the bottom side), 92 nets.

## KiCad design pcb/pipar.kicad_pcb

Board: 2 copper layers, 139.4 x 158.3 mm, 87 parts (28 on the bottom side), 52 nets.

Parts:
BAT+: BAT+; TestPoint_THTPad_D2.0mm_Drill1.0mm
BAT-: BAT-; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
Brd1: SSD1306; 128x64OLED_0.91
CH1, CH2, CH3, CH4, CH5, CH6, CH7, CH8, CH9, CH10, CH11, CH12, CH13, CH14, CH15, CH16, CH17, CH18, CH19, CH20, CH21, CH22, CH23, CH24, CH25, CH26: KSwitch; Kailh_socket_PG1350_reversible
CH28: RotaryEncoder_Switch; RotaryEncoder_Bourns_Vertical_PEL11L-4xxxF-Sxxxx_1
D1, D1#2, D2, D2#2, D3, D3#2, D4, D4#2, D5, D5#2, D6, D6#2, D7, D7#2, D8, D8#2, D9, D9#2, D10, D10#2, D11, D11#2, D12, D12#2, D13, D13#2, D14, D14#2, D15, D15#2, D16, D16#2, D17, D17#2, D18, D18#2, D19, D20, D21, D22, D23, D24, D25, D26: D; Nexperia_CFP3_SOD-123W
M2, M2#2, M2#3, M2#4, M2#5, M2#6, M2#7: MountingHole_2.2mm_M2
SW1, SW1#2, SW2: SW_Wuerth_450301014042; SW_SPDT_PCM12
TP1: BAT-; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP2: BAT+; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
U2: nice_nano

Connections:
GND: BAT-.1, Brd1.1 (GND), CH28.C, CH28.S1, TP1.1, U2.3 (GND), U2.4 (GND), U2.23 (GND)
unnamed: Brd1.3 (SCL), U2.6 (P0.20)
unnamed: Brd1.4 (SDA), U2.5 (P0.17)
unnamed: Brd1.2 (VCC), U2.21 (VCC)
unnamed: CH1.2, D1.2 (A), D1#2.2 (A)
unnamed: D1.1 (K), D1#2.1 (K), D4.1 (K), D4#2.1 (K), D7.1 (K), D7#2.1 (K), D10.1 (K), D10#2.1 (K), D13.1 (K), D13#2.1 (K), D16.1 (K), D16#2.1 (K)
unnamed: CH2.2, D2.2 (A), D2#2.2 (A)
unnamed: CH3.2, D3.2 (A), D3#2.2 (A)
unnamed: CH4.2, D4.2 (A), D4#2.2 (A)
unnamed: CH5.2, D5.2 (A), D5#2.2 (A)
unnamed: CH6.2, D6.2 (A), D6#2.2 (A)
unnamed: CH7.2, D7.2 (A), D7#2.2 (A)
unnamed: CH8.2, D8.2 (A), D8#2.2 (A)
unnamed: CH9.2, D9.2 (A), D9#2.2 (A)
unnamed: CH10.2, D10.2 (A), D10#2.2 (A)
unnamed: CH11.2, D11.2 (A), D11#2.2 (A)
unnamed: D2.1 (K), D2#2.1 (K), D5.1 (K), D5#2.1 (K), D8.1 (K), D8#2.1 (K), D11.1 (K), D11#2.1 (K), D14.1 (K), D14#2.1 (K), D17.1 (K), D17#2.1 (K)
unnamed: CH12.2, D12.2 (A), D12#2.2 (A)
unnamed: D3.1 (K), D3#2.1 (K), D6.1 (K), D6#2.1 (K), D9.1 (K), D9#2.1 (K), D12.1 (K), D12#2.1 (K), D15.1 (K), D15#2.1 (K), D18.1 (K), D18#2.1 (K)
unnamed: CH13.2, D13.2 (A), D13#2.2 (A)
unnamed: CH14.2, D14.2 (A), D14#2.2 (A)
unnamed: CH15.2, D15.2 (A), D15#2.2 (A)
unnamed: CH16.2, D16.2 (A), D16#2.2 (A)
unnamed: CH17.2, D17.2 (A), D17#2.2 (A)
unnamed: CH18.2, D18.2 (A), D18#2.2 (A)
unnamed: CH19.2, D19.2 (A)
unnamed: D19.1 (K), D22.1 (K), U2.8 (P0.24)
unnamed: CH20.2, D20.2 (A)
unnamed: D20.1 (K), D23.1 (K), D25.1 (K), U2.9 (P1.00)
unnamed: CH21.2, D21.2 (A)
unnamed: D21.1 (K), D24.1 (K), D26.1 (K), U2.10 (P0.11)
unnamed: CH22.2, D22.2 (A)
unnamed: CH23.2, D23.2 (A)
unnamed: CH24.2, D24.2 (A)
unnamed: CH25.2, D25.2 (A)
unnamed: CH26.2, D26.2 (A)
unnamed: SW1.1 (B), SW1#2.1 (B)
unnamed: SW1.2 (C), SW1#2.2 (C), TP2.1
unnamed: SW2.1 (B), U2.24 (BATIN/P0.04)
unnamed: BAT+.1, SW2.2 (C)
unnamed: CH16.1, CH17.1, CH18.1
unnamed: CH7.1, CH8.1, CH9.1
unnamed: CH4.1, CH5.1, CH6.1
unnamed: CH13.1, CH14.1, CH15.1
unnamed: CH10.1, CH11.1, CH12.1
unnamed: CH1.1, CH2.1, CH3.1
unnamed: CH28.B, U2.19 (AIN5/P0.29)
unnamed: CH28.A, U2.20 (AIN7/P0.31)
unnamed: CH25.1, CH26.1, U2.15 (P1.11)
unnamed: CH22.1, CH23.1, CH24.1, U2.16 (P1.13)
unnamed: CH19.1, CH20.1, CH21.1, U2.17 (P1.15)
unnamed: CH28.S2, U2.2 (RX1/P0.08)

## Commit log (part)

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2024-08-04 renames file
2024-08-04 testing
2024-08-04 renames keymap
2024-08-04 fixes defconfig
2024-08-04 disables logging
2024-08-04 trying to get ble to work
2024-08-05 adds matrix transform
2024-08-05 testing dongle without transform
2024-08-05 include pipar_test dtsi, but choose the mock scan
2024-08-06 test adding tabs
2024-08-08 change how pins are handled
2024-08-08 reverse cols and flip rows
2024-08-08 updates map
2024-08-08 updates dongle transofrm
2024-08-08 start over but with loggnig
2024-08-08 improves map
2024-08-08 matrix
2024-08-08 test dongle fun
2024-08-08 reset RC positions
2024-08-08 removes typos
2024-08-08 move key map
2024-08-08 test if all is bgv
2024-08-08 reverse cols
2024-08-08 flip tab and esc
2024-08-08 try right side
2024-08-08 fixes right side mapping, updates dongle mapping too
2024-08-08 cleans file
2024-09-19 updates the pcb for flake
2024-09-19 Adds pictures of products
2024-09-19 Updates the prod pcb file
2024-09-19 Adds missing heat inserts and screws
2024-09-24 restructure and seperate pcbs
2024-09-24 Restructure and separate PCBs into individual folders
2024-09-25 improves gitignore
2024-09-25 implements schematic
2024-10-01 schematic done with added button for reset on xiao
2024-10-03 first fab added
2024-10-05 Adds plate file
2024-10-06 moves the through hole away from pad
2024-10-09 starts work on t460s board
2024-10-11 Push an update to fix encoder issues on flake
2024-10-11 add logging
2024-10-11 changes places around
2024-10-11 fixes typo
2024-10-14 try changing sensor
2024-10-15 whitespace
2024-10-18 starts work on t460s board 2
2024-10-20 working on trackpoint
2024-10-21 Recreated Sool & Pipar for production run
2024-10-21 updates pictures and readme
2024-10-21 Updates PCB gerber files for flake
2024-10-21 Adds PCBWay zip and adds on off hints
2024-10-21 Adds a basic build guide for pipar and sool
2024-10-22 Adds a video link to manual
2024-10-23 slightly better format
2024-10-23 fixes new line
2024-10-25 Reworks Pipar Flake to add LEDs and a bigger place for battery
2024-10-25 slightly change the cut to be more straight
2024-11-09 adds lights
2024-11-09 test building
2024-11-10 enable logging
2024-11-10 swap sda and scl pins
2024-11-27 flake changes
2024-11-27 rename from pipar to pipar_sool
2024-11-27 try adding support for studio
2024-11-27 rename missing sool
2024-11-27 changes kscan value
2024-11-27 remove kscan
2024-11-27 adds missing snippet
2024-11-27 more changes
2024-11-27 remove kscan line
2024-11-27 fixes pipar_sool naming
2024-11-27 only define kscan in one place
2024-11-27 move the studio part just to dongle
2024-11-27 add unlock studio
2024-12-01 Updates readme with latest info
2024-12-16 adds pipar tria
2024-12-16 adds missing overlay file
2024-12-16 change one of the pins because mine is broken
2024-12-16 change it back
2024-12-16 use the bottom pins
2024-12-29 updates the physical layout to match the real layout more
2024-12-29 updates physical layout
2024-12-29 removes faulty kscan
2024-12-29 get rid of bloat
2025-01-19 start work on pnp version
2025-01-19 Further changes to placement
2025-01-22 try out some settings
2025-01-22 set the display
2025-01-22 prospector
2025-01-22 add name
2025-01-22 add overlay
2025-01-24 dont build with prospector
2025-01-24 wrong reso
2025-01-24 adds a section for the display part
2025-01-24 since there aint no cs pin, dont use it
2025-01-24 get rid of studio stuff
2025-01-24 try more stuff
2025-01-24 just do something, please :S
2025-01-24 arst
2025-01-24 set it high lol
2025-01-24 try without
2025-01-24 try the prospector again
2025-01-24 try to set the pins twice!
2025-01-24 gets rid of fluff stuff and enables back studio
2025-01-24 set back
2025-01-24 start of creating newer models
2025-01-26 add back the comments
2025-01-26 set back the sensor options
2025-01-27 delay
2025-02-17 add changes
2025-02-17 disable studiio
2025-02-17 set logging in another place
2025-02-17 remove studio
2025-02-17 disable logging
2025-02-17 disable studio on both
2025-02-21 set back the studio support
2025-02-28 gets rid of submodules
2025-02-28 Remove obsolete files and update KiCad project settings for compatibility
2025-03-01 remove bloat folder
2025-03-01 further improvments and cleanup
2025-03-01 copper refill
2025-03-01 add pipar_sool_traces image and update README with V3 details
2025-03-01 add pipar_sool_v2.zip and update README for V2 details
2025-03-01 tiny changes
2025-03-02 updates the placement of keys
2025-03-02 push initial schema for t460s
2025-03-03 push current changes
2025-03-13 more pipar poimt progress
2025-03-18 more progress on pipar point
2025-03-26 update pipar point traces and add more connection pads
2025-03-29 one side is done
2025-04-12 pipar point panelized
2025-04-14 updates antennas
2025-05-09 review and some routing improvements
2025-05-10 pipar point v1, prototype
2025-05-15 Fixes diode footprint to be sod-523, removes text
2025-05-20 update traces for new footprints
2025-05-22 fixes traces around leds
2025-05-23 change footprints, fix traces, fix groundfill
2025-06-05 rename from left_central to just central to work better with miryoku
2025-06-17 add 3D render images for Pipar Point and update README with prototype phase details
2025-06-17 forgot to add info about wireless charging
2025-06-23 replace picture used for pipar chip
2025-06-26 build chip
2025-06-26 remove bloat
2025-06-26 removes encoder
2025-06-26 correct the number of rows and cols
2025-06-26 try different way
2025-06-27 test out tap stuff
2025-06-27 missing semi :)
2025-06-27 remove comas
2025-07-06 add gaming layer to pipar chip
2025-07-06 add combo definitions for gaming and symbols layers
2025-07-06 adjust combo timeout and require prior idle settings for gaming and symbols layers
2025-07-06 update Bluetooth configuration and adjust tapping term for tap dance behaviors
2025-07-06 add numbers layer and update combo definitions for improved functionality
2025-07-06 fix the typos in bt naming
2025-07-19 update keymap name
2025-07-19 change the remote to my own
2025-07-25 updates pg1316 footprints
2025-07-25 adds pipar chip as its own board
2025-07-25 Update readme with Pipar Chip pictures
2025-08-09 update the ESD component to be in bom
2025-08-10 Fix include statements in Pipar Chip ISP1807 DTS file
2025-08-10 rename the pipar chip to be shorter
2025-08-10 Update LED GPIO configuration to active low and optimize keymap bindings
2025-08-10 enable backlight
2025-08-10 Add backlight configuration to device tree
2025-08-10 add xtools support
2025-08-16 Update backlight brightness start value to 70
2025-08-22 feat: initialize pipar_chip_isp1807 rmk keyboard firmware
    - Add Cargo.toml for project dependencies and configuration.
    - Create Makefile.toml for build tasks including LLVM tools and firmware generation.
    - Add README.md with instructions for uf2 firmware generation and flashing.
    - Implement build.rs to manage memory layout and generate Vial configuration.
    - Define keyboard layout and settings in keyboard.toml.
    - Specify memory layout for NRF52840 in memory.x.
2025-08-22 Update backlight brightness start value to 100
2025-08-24 chore: update dependencies and versions in Cargo files
2025-08-24 fix: correct backlight toggle key in keyboard layout and update dependencies formatting
2025-08-24 fix: update backlight toggle key in keyboard layout
2025-08-29 start work on pipar point v3
2025-08-30 updates the pinout for the isp1807
2025-09-01 Place keys on the left hand side
2025-09-02 grouping
2025-09-02 places more components
2025-09-05 Add SK8707-01 and SK8707-01-0C Sensor footprints to Trackpoint library
2025-09-07 more things :)
2025-09-12 right side routed, progress on left side
2025-09-14 small changes
2025-09-15 tuned usb data tracks
2025-09-15 adds a proper battery connector
2025-09-16 fixes small trace issues
2025-09-16 added rounder tracks version
2025-09-17 stuff, i dont remember
2025-09-20 Update pipar_point_v3.zip with latest production files
2025-09-21 who knows
2025-09-21 finished unibody urchin, maybe ;)
2025-09-21 changed the body to make room for the oled screen
2025-09-21 Update pipar_urchin_unibody.zip with latest production files
2025-09-22 updates production files
2025-10-06 bumping the production files
2025-10-31 set the version to v0.3.0
2025-10-31 deletes rmk stuff for now
2025-10-31 pipar_point firmware init
2025-10-31 Add pipar_point configuration files and update layouts
    - Introduced pipar_point.dtsi with device tree configurations.
    - Added pinctrl settings for I2C in pipar_point-pinctrl.dtsi.
    - Updated physical layout to use pipar_matrix in pipar_point-layouts.dtsi.
    - Created keymap in pipar_point.keymap for key bindings.
    - Added left and right device tree source files for pipar_point.
2025-10-31 Update pipar_builds.yaml to include pipar_point_left and pipar_point_right boards
2025-10-31 file rename fix
2025-10-31 Update physical layout transformation to use matrix_transform0
2025-10-31 fix the dts file ending
2025-11-01 col2row
2025-11-01 Update GPIO configuration and matrix transformation offsets for pipar_point boards
2025-11-01 Refactor matrix configuration for pipar_point boards: update GPIO settings and transform offsets
2025-11-01 Update keymap transformation for pipar_point boards: align formatting for better readability
2025-11-01 get rid of the 3.0.0 rev part
2025-11-01 try being fancy
2025-11-01 pipar_sool is migrated
2025-11-01 all the cool folks use the zmk module setup now
2025-11-01 try different board defs
2025-11-02 bring in the urob helpers and unicode
2025-11-02 try some new fancy builds
2025-11-02 fixes some more typos
2025-11-02 use clearer if
2025-11-02 see if expanding works
2025-11-02 try with some prep
2025-11-02 gets rid of helpers
2025-11-02 set the run name to be more dynamic
2025-11-02 no urob
2025-11-02 hmmmmmm
2025-11-02 unhmmm
2025-11-02 adds driver
2025-11-03 multiple snippets are added differently
2025-11-03 disable studio for now and just keep logging on the right side
2025-11-04 updates the stl file
2025-11-05 adds back studio support
2025-11-06 enables logging again
2025-11-07 removes snippets
2025-11-07 add studio-rpc-usb-uart snippet to pipar_point_right
2025-11-08 try building with the new structure
2025-11-08 add settings_reset shield to pipar_point@left in build workflow
2025-11-08 try building with studio and logs
2025-11-08 remove logging again
2025-11-09 updates the readme a bit more
2025-11-13 try setting up uart
2025-11-16 do some work for the dongle
2025-11-18 feat: add dongle fix: move footprint folders around generates new production files mentions pcbway as the v3 sponsor on silkscreen
2025-11-21 adds dongle cover part updates production files
2025-11-21 pcb: regenerate netlist and update board/production archives
    - Update KiCad board and production archives (pipar_point_v3.kicad_pcb.zip,
    Pipar_Point_V3.1.zip).
    - Regenerate production netlist (production/netlist.ipc) from the updated PCB:
    - Large refresh of VIA placements, testpoints and component pad coordinates.
    - Reconcile and normalize many connector and dongle nets (USB_D+/USB_D-,
    VBUS, VSYS, 3.3V, BAT_*), plus CC/POWER nets.
2025-11-21 pcb: fix 3D model paths/orientation and update front render
    - Use ${PIPAR_FOOTPRINTS} for EVP-BB1AAB000 3D model path
    - Tweak EVPBB2A9B000 model offset/rotation
    - Replace updated .extra/pipar_point_front_3d.png
2025-11-21 update the step file
2025-12-09 ci: use correct trackpoint snippet (studio-rpc-usb-uart) in build_pipar_point workflow
2025-12-19 pcb: update manufacturer and Mouser part numbers in schematics
    Replace IRLML6344TRPBF (942-IRLML6344TRPBF) with SI2342DS-T1-GE3 (78-SI2342DS-T1-GE3) in keymatrix.kicad_sch.
    Correct GRM188R61E106KA73J -> GRM188R61E106KA73D and update corresponding Mouser codes (…KA3J -> …KA3D) in power.kicad_sch.
2026-04-03 remove logging
2026-05-12 updated stencil files
2026-05-21 Add .gitignore to exclude build and configuration files
2026-05-21 Update README.md with firmware build instructions and update zmk-keyboard-pipar submodule
2026-05-21 Fix board identifiers in build_all.yaml and update README.md with correct GitHub Actions workflow link
2026-05-21 Remove GitHub Actions workflow for building Pipar firmwares
2026-06-18 generate html bom
