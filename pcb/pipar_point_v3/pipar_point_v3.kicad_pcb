# Repository RasmusKoit/pipar (continued)

## KiCad design pcb/pipar_chip/pipar_chip.kicad_pcb (continued)

Parts:
D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: D_Small; D_SOD-523; Manufacturer_Part_Number 1N4148WT-7; Mouser Part Number 621-1N4148WT
KHS1, KHS2, KHS3, KHS4, KHS5, KHS6, KHS7, KHS8, KHS9, KHS10, KHS11, KHS12: KHS; CPG1316S01D02_front_mikefives
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12: LED_Small; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63BT5UW; Mouser Part Number 743-IN-S63BT5UW
Q1: AO3400A; SOT-23; Manufacturer_Part_Number IRLML6344TRPBF; Mouser Part Number 942-IRLML6344TRPBF
R10: 5.1k; R_0603_1608Metric; Manufacturer_Part_Number 603-RC0603FR-075K1L; Mouser Part Number 603-RC0603FR-075K1L
R11: 1.5k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-071K5L; Mouser Part Number 603-RC0603FR-071K5L
TP9: TestPoint_Probe; TestPoint_Pad_D1.0mm

Connections:
/3.3VOUT: LED1.2 (A), LED2.2 (A), LED3.2 (A), LED4.2 (A), LED5.2 (A), LED6.2 (A), LED7.2 (A), LED8.2 (A), LED9.2 (A), LED10.2 (A), LED11.2 (A), LED12.2 (A), TP9.1; also elsewhere on the board
/Backlight_trigger: Q1.1 (G), R10.2; also elsewhere on the board
/Col0: KHS1.1, KHS2.1, KHS3.1; also elsewhere on the board
/Col1: KHS4.1, KHS5.1, KHS6.1; also elsewhere on the board
/Col2: KHS7.1, KHS8.1, KHS9.1; also elsewhere on the board
/Col3: KHS10.1, KHS11.1, KHS12.1; also elsewhere on the board
/KeyMatrix/LEDOut: Q1.3 (D), R11.2
/Row0: D6.1 (K), D9.1 (K), D12.1 (K), D15.1 (K); also elsewhere on the board
/Row1: D7.1 (K), D10.1 (K), D13.1 (K), D16.1 (K); also elsewhere on the board
/Row2: D8.1 (K), D11.1 (K), D14.1 (K), D17.1 (K); also elsewhere on the board
GND: Q1.2 (S), R10.1; also elsewhere on the board
unnamed: D6.2 (A), KHS1.2
unnamed: D7.2 (A), KHS2.2
unnamed: D8.2 (A), KHS3.2
unnamed: D9.2 (A), KHS4.2
unnamed: D10.2 (A), KHS5.2
unnamed: D11.2 (A), KHS6.2
unnamed: D12.2 (A), KHS7.2
unnamed: D13.2 (A), KHS8.2
unnamed: D14.2 (A), KHS9.2
unnamed: D15.2 (A), KHS10.2
unnamed: D16.2 (A), KHS11.2
unnamed: D17.2 (A), KHS12.2
unnamed: LED1.1 (K), LED2.1 (K), LED3.1 (K), LED4.1 (K), LED5.1 (K), LED6.1 (K), LED7.1 (K), LED8.1 (K), LED9.1 (K), LED10.1 (K), LED11.1 (K), LED12.1 (K), R11.1

Notes on the sheet:
Index
Key
Thumbs
Middle
100R * N Leds
OuterIndex

Board: 4 copper layers, 68.0 x 61.3 mm, 87 parts (15 on the bottom side), 51 nets.

## KiCad design pcb/pipar_point/pipar_point.kicad_pcb

Notes on the sheet:
Right half
Left half

Parts:
D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109: D_Small; D_0402_1005Metric
H90, H91, H92, H93, H94, H95, H96, H97, H98, H99, H100, H101, H102, H103, H104, H105, H106, H107, H108, H109: SwitchHoles; SwitchHoles_Kailh_Choc_V1V2
KHS90, KHS91, KHS92, KHS93, KHS94, KHS95, KHS96, KHS97, KHS98, KHS99, KHS100, KHS101, KHS102, KHS103, KHS104, KHS105, KHS106, KHS107, KHS108, KHS109: KHS; Kailh_HS_Socket
LED90, LED91, LED92, LED93, LED94, LED95, LED96, LED97, LED98, LED99, LED100, LED101, LED102, LED103, LED104, LED105, LED106, LED107, LED108, LED109: LED_Small; LED_0402_1005Metric
LR90, LR91, LR92, LR93, LR94, LR95, LR96, LR97, LR98, LR99, LR100, LR101, LR102, LR103, LR104, LR105, LR106, LR107, LR108, LR109: R_Small; R_0402_1005Metric

Connections:
/Keymatrix/Col0: KHS90.1, KHS91.1, KHS92.1; also elsewhere on the board
/Keymatrix/Col1: KHS93.1, KHS94.1, KHS95.1; also elsewhere on the board
/Keymatrix/Col2: KHS96.1, KHS97.1, KHS98.1; also elsewhere on the board
/Keymatrix/Col3: KHS99.1, KHS100.1, KHS101.1; also elsewhere on the board
/Keymatrix/Col4: KHS102.1, KHS103.1, KHS104.1; also elsewhere on the board
/Keymatrix/Col5: KHS105.1, KHS106.1, KHS107.1; also elsewhere on the board
/Keymatrix/Col6: KHS108.1, KHS109.1; also elsewhere on the board
/Keymatrix/LEDOut: LR90.2, LR91.2, LR92.2, LR93.2, LR94.2, LR95.2, LR96.2, LR97.2, LR98.2, LR99.2, LR100.2, LR101.2, LR102.2, LR103.2, LR104.2, LR105.2, LR106.2, LR107.2, LR108.2, LR109.2; also elsewhere on the board
/Keymatrix/Row0: D90.1 (K), D93.1 (K), D96.1 (K), D99.1 (K), D102.1 (K), D105.1 (K); also elsewhere on the board
/Keymatrix/Row1: D91.1 (K), D94.1 (K), D97.1 (K), D100.1 (K), D103.1 (K), D106.1 (K), D108.1 (K); also elsewhere on the board
/Keymatrix/Row2: D92.1 (K), D95.1 (K), D98.1 (K), D101.1 (K), D104.1 (K), D107.1 (K), D109.1 (K); also elsewhere on the board
/Keymatrix/Vcc: LED90.2 (A), LED91.2 (A), LED92.2 (A), LED93.2 (A), LED94.2 (A), LED95.2 (A), LED96.2 (A), LED97.2 (A), LED98.2 (A), LED99.2 (A), LED100.2 (A), LED101.2 (A), LED102.2 (A), LED103.2 (A), LED104.2 (A), LED105.2 (A), LED106.2 (A), LED107.2 (A), LED108.2 (A), LED109.2 (A); also elsewhere on the board
unnamed: D90.2 (A), KHS90.2
unnamed: D91.2 (A), KHS91.2
unnamed: D92.2 (A), KHS92.2
unnamed: D93.2 (A), KHS93.2
unnamed: D94.2 (A), KHS94.2
unnamed: D95.2 (A), KHS95.2
unnamed: D96.2 (A), KHS96.2
unnamed: D97.2 (A), KHS97.2
unnamed: D98.2 (A), KHS98.2
unnamed: D99.2 (A), KHS99.2
unnamed: D100.2 (A), KHS100.2
unnamed: D101.2 (A), KHS101.2
unnamed: D102.2 (A), KHS102.2
unnamed: D103.2 (A), KHS103.2
unnamed: D104.2 (A), KHS104.2
unnamed: D105.2 (A), KHS105.2
unnamed: D106.2 (A), KHS106.2
unnamed: D107.2 (A), KHS107.2
unnamed: D108.2 (A), KHS108.2
unnamed: D109.2 (A), KHS109.2
unnamed: LED90.1 (K), LR90.1
unnamed: LED91.1 (K), LR91.1
unnamed: LED92.1 (K), LR92.1
unnamed: LED93.1 (K), LR93.1
unnamed: LED94.1 (K), LR94.1
unnamed: LED95.1 (K), LR95.1
unnamed: LED96.1 (K), LR96.1
unnamed: LED97.1 (K), LR97.1
unnamed: LED98.1 (K), LR98.1
unnamed: LED99.1 (K), LR99.1
unnamed: LED100.1 (K), LR100.1
unnamed: LED101.1 (K), LR101.1
unnamed: LED102.1 (K), LR102.1
unnamed: LED103.1 (K), LR103.1
unnamed: LED104.1 (K), LR104.1
unnamed: LED105.1 (K), LR105.1
unnamed: LED106.1 (K), LR106.1
unnamed: LED107.1 (K), LR107.1
unnamed: LED108.1 (K), LR108.1
unnamed: LED109.1 (K), LR109.1

Parts of its further copies:
D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128, D129: D_Small; D_0402_1005Metric
H110, H111, H112, H113, H114, H115, H116, H117, H118, H119, H120, H121, H122, H123, H124, H125, H126, H127, H128, H129: SwitchHoles; SwitchHoles_Kailh_Choc_V1V2
KHS110, KHS111, KHS112, KHS113, KHS114, KHS115, KHS116, KHS117, KHS118, KHS119, KHS120, KHS121, KHS122, KHS123, KHS124, KHS125, KHS126, KHS127, KHS128, KHS129: KHS; Kailh_HS_Socket
LED110, LED111, LED112, LED113, LED114, LED115, LED116, LED117, LED118, LED119, LED120, LED121, LED122, LED123, LED124, LED125, LED126, LED127, LED128, LED129: LED_Small; LED_0402_1005Metric
LR110, LR111, LR112, LR113, LR114, LR115, LR116, LR117, LR118, LR119, LR120, LR121, LR122, LR123, LR124, LR125, LR126, LR127, LR128, LR129: R_Small; R_0402_1005Metric

Connections of its further copies:
/Keymatrix_left/Col0: KHS110.1, KHS111.1, KHS112.1; also elsewhere on the board
/Keymatrix_left/Col1: KHS113.1, KHS114.1, KHS115.1; also elsewhere on the board
/Keymatrix_left/Col2: KHS116.1, KHS117.1, KHS118.1; also elsewhere on the board
/Keymatrix_left/Col3: KHS119.1, KHS120.1, KHS121.1; also elsewhere on the board
/Keymatrix_left/Col4: KHS122.1, KHS123.1, KHS124.1; also elsewhere on the board
/Keymatrix_left/Col5: KHS125.1, KHS126.1, KHS127.1; also elsewhere on the board
/Keymatrix_left/Col6: KHS128.1, KHS129.1; also elsewhere on the board
/Keymatrix_left/LEDOut: LR110.2, LR111.2, LR112.2, LR113.2, LR114.2, LR115.2, LR116.2, LR117.2, LR118.2, LR119.2, LR120.2, LR121.2, LR122.2, LR123.2, LR124.2, LR125.2, LR126.2, LR127.2, LR128.2, LR129.2; also elsewhere on the board
/Keymatrix_left/Row0: D110.1 (K), D113.1 (K), D116.1 (K), D119.1 (K), D122.1 (K), D125.1 (K); also elsewhere on the board
/Keymatrix_left/Row1: D111.1 (K), D114.1 (K), D117.1 (K), D120.1 (K), D123.1 (K), D126.1 (K), D128.1 (K); also elsewhere on the board
/Keymatrix_left/Row2: D112.1 (K), D115.1 (K), D118.1 (K), D121.1 (K), D124.1 (K), D127.1 (K), D129.1 (K); also elsewhere on the board
/Keymatrix_left/Vcc: LED110.2 (A), LED111.2 (A), LED112.2 (A), LED113.2 (A), LED114.2 (A), LED115.2 (A), LED116.2 (A), LED117.2 (A), LED118.2 (A), LED119.2 (A), LED120.2 (A), LED121.2 (A), LED122.2 (A), LED123.2 (A), LED124.2 (A), LED125.2 (A), LED126.2 (A), LED127.2 (A), LED128.2 (A), LED129.2 (A); also elsewhere on the board
unnamed: D110.2 (A), KHS110.2
unnamed: D111.2 (A), KHS111.2
unnamed: D112.2 (A), KHS112.2
unnamed: D113.2 (A), KHS113.2
unnamed: D114.2 (A), KHS114.2
unnamed: D115.2 (A), KHS115.2
unnamed: D116.2 (A), KHS116.2
unnamed: D117.2 (A), KHS117.2
unnamed: D118.2 (A), KHS118.2
unnamed: D119.2 (A), KHS119.2
unnamed: D120.2 (A), KHS120.2
unnamed: D121.2 (A), KHS121.2
unnamed: D122.2 (A), KHS122.2
unnamed: D123.2 (A), KHS123.2
unnamed: D124.2 (A), KHS124.2
unnamed: D125.2 (A), KHS125.2
unnamed: D126.2 (A), KHS126.2
unnamed: D127.2 (A), KHS127.2
unnamed: D128.2 (A), KHS128.2
unnamed: D129.2 (A), KHS129.2
unnamed: LED110.1 (K), LR110.1
unnamed: LED111.1 (K), LR111.1
unnamed: LED112.1 (K), LR112.1
unnamed: LED113.1 (K), LR113.1
unnamed: LED114.1 (K), LR114.1
unnamed: LED115.1 (K), LR115.1
unnamed: LED116.1 (K), LR116.1
unnamed: LED117.1 (K), LR117.1
unnamed: LED118.1 (K), LR118.1
unnamed: LED119.1 (K), LR119.1
unnamed: LED120.1 (K), LR120.1
unnamed: LED121.1 (K), LR121.1
unnamed: LED122.1 (K), LR122.1
unnamed: LED123.1 (K), LR123.1
unnamed: LED124.1 (K), LR124.1
unnamed: LED125.1 (K), LR125.1
unnamed: LED126.1 (K), LR126.1
unnamed: LED127.1 (K), LR127.1
unnamed: LED128.1 (K), LR128.1
unnamed: LED129.1 (K), LR129.1

Notes on the sheet:
Key
OuterIndex
Pinkie
Index
Thumbs
Ring
Middle
OuterPinkie
