# Repository RasmusKoit/pipar (continued)

## KiCad design pcb/pipar_point/pipar_point.kicad_pcb (continued)

Parts:
AE1: Antenna; 2.4GHz-meander-antenna-v2
C1, C4, C13, C19: 4.7uF; C_0402_1005Metric; Manufacturer Part CL05A475KP5NRNC; LCSC C23733
C2, C20: 1uF; C_0402_1005Metric; Manufacturer Part CL05A105KO5NNNC; LCSC C52923
C3: 47nF; C_0402_1005Metric; Manufacturer Part CL05B473KO5NNNC; LCSC C272875
C5: 1nF; C_0402_1005Metric; Manufacturer Part CL05B102KB5NNNC; LCSC C1523
C6: 100pF; C_0402_1005Metric; Manufacturer Part CL05C101JB5NNNC; LCSC C1546
C7, C16, C17, C18: 100nF; C_0402_1005Metric; Manufacturer Part CL05B104KA5NNNC; LCSC C307331
C8, C9, C21, C22: 15pF; C_0402_1005Metric; Manufacturer Part CL05C150JB51PNC; LCSC C1548
C10: 1.5pF; C_0402_1005Metric; Manufacturer Part CL05C1R5CB5NNNC; LCSC C1552
C11, C12: 1pF; C_0402_1005Metric; Manufacturer Part CL05C010CB5NNNC; LCSC C1550
C23: 10nF; C_0402_1005Metric; Manufacturer Part CL05B103KB5NNNC; LCSC C15195
C24: 1000pF/NC; C_0402_1005Metric
C49: 10uF; C_0603_1608Metric; Manufacturer Part CL10A106KP8NNNC; LCSC Part C19702
C62: 4.7uF; C_0402_1005Metric; Manufacturer Part CL05A475KP5NRNC; LCSC Part C23733
C65: 100nF; C_0402_1005Metric; Manufacturer Part CL05B103KB5NNNC; LCSC Part C307331
C67, C69: 4.7uF; C_0402_1005Metric; Manufacturer Part CL05A105KO5NNNC; LCSC C52923
D3: BLUE; LED_0402_1005Metric; Manufacturer Part 19-217/BHC-ZL1M2RY/3T; LCSC C2290
D7: B5819WT; D_SOD-523; Manufacturer Part PMEG4010CEJ; LCSC C8598
D9: CHG; LED_0402_1005Metric; Manufacturer Part 19-217/S2C-AQ1R1B/3T; LCSC C72038
D22: CAPS; LED_0402_1005Metric; Manufacturer Part 19-217/BHC-ZL1M2RY/3T; LCSC C2290
J53: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical_SMD; not fitted
L1: 15nH; L_0402_1005Metric; Manufacturer Part MLG1005S15NJT000; LCSC C27143
L2, L3: 10uH; L_0603_1608Metric; Manufacturer Part MLF1608E100KTD00; LCSC C285968
L4: 3.9nH; L_0402_1005Metric; Manufacturer Part MLG1005S3N9BT000; LCSC C14033
NT1: NetTie_2; net-tie-2-tiny
P1: USB-C; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
Q1: AO3416 N-channel MOSFET; SOT-23; MPN AO3416; LCSC Part Number C479060
R1: 0R; R_0402_1005Metric; Manufacturer Part RC0402FR-070RL; LCSC C17168
R5, R31: 1.5k; R_0402_1005Metric; Manufacturer Part RC0402FR-071K5L; LCSC C25867
R6, R7: 5.1k; R_0402_1005Metric; Manufacturer Part RC0402FR-075K1L; LCSC C25905
R8, R9: 2M; R_0603_1608Metric; Manufacturer Part RC0402FR-072ML; LCSC C22976
R10: 10M; R_0402_1005Metric; Manufacturer Part RC0402FR-0710ML; LCSC C26082
R11: 1M; R_0402_1005Metric; LCSC C26083
R23: 2M; R_0402_1005Metric; Manufacturer Part RC0402FR-072ML; LCSC Part C138014
R25: 10k; R_0402_1005Metric; Manufacturer Part RC0402FR-0710KL; LCSC C25744
R27: 470; R_0402_1005Metric; Manufacturer Part RC0402FR-0710KL; LCSC C25744
R39: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; Part Number PF1206FRF070R01L; JLCPCB ID C127703
SW1: Reset; SW4-SMD-2.8-2.6X1.6X0.53MM; LCSC C318884
TP5: VBAT; TestPoint_Pad_2.5x2.5mm
TP6: BAT GND; TestPoint_Pad_2.5x2.5mm
TP9: W_VBUS; TestPoint_Pad_2.5x2.5mm
TP11: W_GND; TestPoint_Pad_2.5x2.5mm
U2: nRF52840; Nordic_AQFN-73-1EP_7x7mm_P0.5mm; Manufacturer Part NRF52840-QIAA-R; LCSC C190794
U3: ESDR0502NMUTAG; UDFN-6_1.2x1.0mm_P0.4mm; Manufacturer Part ESDR0502NMUTBG; LCSC C327480
U7: XC6220B331MR; SOT-23-5; Manufacturer Part XC6220B331MR-G‎; Digikey 893-1133-1-ND‎
U9: MAX17048; TDFN-8-1EP_2x2mm_P0.5mm_EP0.8x1.2mm; LCSC Part C2682616
U53: MCP73831-2-MC; DFN-8-1EP_3x2mm_P0.5mm_EP1.7x1.4mm
Y1: 32.768 kHz; Crystal_SMD_2012-2Pin_2.0x1.2mm; Manufacturer Part SC20S-12.5PF20PPM; LCSC C99009
Y2: 32MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm; Manufacturer Part Q22FA1280001800; LCSC C2965584

Connections:
/Keymatrix/Col0: U2.A8 (AIN7/P0.31); also elsewhere on the board
/Keymatrix/Col1: U2.A10 (AIN5/P0.29); also elsewhere on the board
/Keymatrix/Col2: U2.A12 (AIN0/P0.02); also elsewhere on the board
/Keymatrix/Col3: U2.A14 (P1.15); also elsewhere on the board
/Keymatrix/Col4: U2.A16 (P1.13); also elsewhere on the board
/Keymatrix/Col5: U2.A20 (P1.10); also elsewhere on the board
/Keymatrix/Col6: U2.B19 (P1.11); also elsewhere on the board
/Keymatrix/LEDOut: Q1.3 (D); also elsewhere on the board
/Keymatrix/Row0: U2.AD16 (P0.20); also elsewhere on the board
/Keymatrix/Row1: U2.AD18 (P0.22); also elsewhere on the board
/Keymatrix/Row2: U2.AD20 (P0.24); also elsewhere on the board
/Keymatrix/Vcc: C62.2, U7.5 (VOUT); also elsewhere on the board
/Trackpointer/CLK: U2.J1 (AIN2/P0.04); also elsewhere on the board
/Trackpointer/DATA: U2.L1 (P0.06); also elsewhere on the board
/Trackpointer/RST: U2.G1 (P0.26); also elsewhere on the board
/nRF52840/ANT: AE1.1 (A), C10.2, R1.2
/nRF52840/BAT_I2C_SCL: U2.R1 (TRACEDATA3/P1.09), U9.7 (SCL)
/nRF52840/BAT_I2C_SDA: U2.N1 (P0.08), U9.8 (SDA)
/nRF52840/BAT_VOLT: C23.2, R9.2, R10.1, U2.U1 (TRACEDATA1/P0.12)
/nRF52840/BLUE_LED: D3.2 (A), U2.AD10 (P0.15)
/nRF52840/Backlight_trigger: Q1.1 (G), R39.2, U2.AD8 (P0.13)
/nRF52840/CAPS_LED: D22.2 (A), U2.AD12 (P0.17)
/nRF52840/CC1: P1.A5 (CC), R6.1
/nRF52840/CC2: P1.B5 (VCONN), R7.1
/nRF52840/MISO: U2.U24 (P1.04)
/nRF52840/MOSI: U2.W24 (P1.02)
/nRF52840/PPH_VCC_CTRL: R23.1, U2.L24 (NFC1/P0.09), U7.3 (CE)
/nRF52840/RESET: SW1.1, U2.AC9 (P0.14), U2.AC11 (P0.16), U2.AC13 (P0.18/~RESET)
/nRF52840/SCK: U2.R24 (P1.06)
/nRF52840/SWC: J53.1, U2.AA24 (SWDCLK)
/nRF52840/SWD: J53.3, U2.AC24 (SWDIO)
/nRF52840/SWO: J53.5, U2.AD22 (TRACEDATA0/P1.00)
/nRF52840/USB_D+: J53.4, P1.A6 (D+), P1.B6 (D+), U2.AD6 (D+), U3.5 (D+)
/nRF52840/USB_D-: J53.6, P1.A7 (D-), P1.B7 (D-), U2.AD4 (D-), U3.6 (VBUS)
/nRF52840/VBAT: C13.2, C49.2, C65.2, C69.1, R8.1, TP5.1, U2.Y2 (VDDH), U7.1 (VIN), U9.2 (CELL), U9.3 (VDD), U53.3 (V_{BAT}), U53.4 (V_{BAT})
/nRF52840/VBUS: C1.2, D7.2 (A), J53.2, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), U2.AD2 (VBUS), U3.4 (D-)
/nRF52840/VDD_NRF: C16.2, C17.2, C18.2, C19.2, C20.2, L3.1, U2.A22 (VDD), U2.AD14 (VDD), U2.AD23 (VDD), U2.B1 (VDD), U2.W1 (VDD)
/nRF52840/VSS_PA: C12.1, NT1.1, U2.F23 (VSS_PA)
/nRF52840/W_VBUS: C67.1, D7.1 (K), D9.2 (A), TP9.1, U53.1 (V_{DD}), U53.2 (V_{DD})
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.1, C13.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.2, C22.2, C23.1, C24.2, C49.1, C62.1, C65.1, C67.2, C69.2, J53.7, J53.8, NT1.2, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), Q1.2 (S), R5.1, R6.2, R7.2, R10.2, R11.1, R23.2, R25.2, R31.1, R39.1, SW1.2, TP6.1, TP11.1, U2.B7 (VSS), U2.EP (VSS), U3.1 (GND), U7.2 (GND), U9.1 (CTG), U9.4 (GND), U9.6 (QSTRT), U9.9 (EP), U53.6 (V_{SS}), Y2.2, Y2.4; also elsewhere on the board
unnamed: C11.2, L4.1, R1.1
unnamed: D3.1 (K), R5.2
unnamed: D9.1 (K), R27.1
unnamed: D22.1 (K), R31.2
unnamed: L1.2, L2.1
unnamed: C24.1, P1.S1 (SHIELD), R11.2
unnamed: R8.2, R9.1
unnamed: C12.2, L4.2, U2.H23 (ANT)
unnamed: L2.2, U2.B3 (DCC)
unnamed: L3.2, U2.AB2 (DCCH)
unnamed: C7.1, U2.C1 (DEC1)
unnamed: C6.1, U2.D23 (DEC3)
unnamed: C2.2, C3.2, L1.1, U2.B5 (DEC4), U2.E24 (DEC6)
unnamed: C5.1, U2.N24 (DEC5)
unnamed: C4.1, U2.AC5 (DECUSB)
unnamed: C21.1, U2.B24 (XC1), Y2.1
unnamed: C22.1, U2.A23 (XC2), Y2.3
unnamed: C8.2, U2.D2 (XL1/P0.00), Y1.1
unnamed: C9.2, U2.F2 (XL2/P0.01), Y1.2
unnamed: R25.1, U53.8 (PROG)
unnamed: R27.2, U53.5 (STAT)

Parts of its further copies:
AE2: Antenna; 2.4GHz-meander-antenna-v2
C25: 1.5pF; C_0402_1005Metric; Manufacturer Part CL05C1R5CB5NNNC; LCSC C1552
C26, C29: 1pF; C_0402_1005Metric; Manufacturer Part CL05C010CB5NNNC; LCSC C1550
C27, C28, C37, C38: 15pF; C_0402_1005Metric; Manufacturer Part CL05C150JB51PNC; LCSC C1548
C30, C40, C42, C43: 100nF; C_0402_1005Metric; Manufacturer Part CL05B104KA5NNNC; LCSC C307331
C31: 100pF; C_0402_1005Metric; Manufacturer Part CL05C101JB5NNNC; LCSC C1546
C32: 1nF; C_0402_1005Metric; Manufacturer Part CL05B102KB5NNNC; LCSC C1523
C33, C34, C39, C44: 4.7uF; C_0402_1005Metric; Manufacturer Part CL05A475KP5NRNC; LCSC C23733
C35, C45: 1uF; C_0402_1005Metric; Manufacturer Part CL05A105KO5NNNC; LCSC C52923
C36: 47nF; C_0402_1005Metric; Manufacturer Part CL05B473KO5NNNC; LCSC C272875
C41: 10nF; C_0402_1005Metric; Manufacturer Part CL05B103KB5NNNC; LCSC C15195
C46: 1000pF/NC; C_0402_1005Metric
C63: 10uF; C_0603_1608Metric; Manufacturer Part CL10A106KP8NNNC; LCSC Part C19702
C64: 4.7uF; C_0402_1005Metric; Manufacturer Part CL05A475KP5NRNC; LCSC Part C23733
C66: 100nF; C_0402_1005Metric; Manufacturer Part CL05B103KB5NNNC; LCSC Part C307331
C68, C70: 4.7uF; C_0402_1005Metric; Manufacturer Part CL05A105KO5NNNC; LCSC C52923
D4: BLUE; LED_0402_1005Metric; Manufacturer Part 19-217/BHC-ZL1M2RY/3T; LCSC C2290
D8: B5819WT; D_SOD-523; Manufacturer Part PMEG4010CEJ; LCSC C8598
D10: CHG; LED_0402_1005Metric; Manufacturer Part 19-217/S2C-AQ1R1B/3T; LCSC C72038
D23: CAPS; LED_0402_1005Metric; Manufacturer Part 19-217/BHC-ZL1M2RY/3T; LCSC C2290
L5: 3.9nH; L_0402_1005Metric; Manufacturer Part MLG1005S3N9BT000; LCSC C14033
L6: 15nH; L_0402_1005Metric; Manufacturer Part MLG1005S15NJT000; LCSC C27143
L7, L8: 10uH; L_0603_1608Metric; Manufacturer Part MLF1608E100KTD00; LCSC C285968
NT2: NetTie_2; net-tie-2-tiny
P2: USB-C; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
Q2: AO3416 N-channel MOSFET; SOT-23; MPN AO3416; LCSC Part Number C479060
R12: 0R; R_0402_1005Metric; Manufacturer Part RC0402FR-070RL; LCSC C17168
R13, R14: 2M; R_0603_1608Metric; Manufacturer Part RC0402FR-072ML; LCSC C22976
R15: 10M; R_0402_1005Metric; Manufacturer Part RC0402FR-0710ML; LCSC C26082
R16, R32: 1.5k; R_0402_1005Metric; Manufacturer Part RC0402FR-071K5L; LCSC C25867
R17: 1M; R_0402_1005Metric; LCSC C26083
R20, R21: 5.1k; R_0402_1005Metric; Manufacturer Part RC0402FR-075K1L; LCSC C25905
R24: 2M; R_0402_1005Metric; Manufacturer Part RC0402FR-072ML; LCSC Part C138014
R26: 10k; R_0402_1005Metric; Manufacturer Part RC0402FR-0710KL; LCSC C25744
R28: 470; R_0402_1005Metric; Manufacturer Part RC0402FR-0710KL; LCSC C25744
R40: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; Part Number PF1206FRF070R01L; JLCPCB ID C127703
SW2: Reset; SW4-SMD-2.8-2.6X1.6X0.53MM; LCSC C318884
TP7: VBAT; TestPoint_Pad_2.5x2.5mm
TP8: BAT GND; TestPoint_Pad_2.5x2.5mm
TP10: W_VBUS; TestPoint_Pad_2.5x2.5mm
TP12: W_GND; TestPoint_Pad_2.5x2.5mm
U4: nRF52840; Nordic_AQFN-73-1EP_7x7mm_P0.5mm; Manufacturer Part NRF52840-QIAA-R; LCSC C190794
U5: ESDR0502NMUTAG; UDFN-6_1.2x1.0mm_P0.4mm; Manufacturer Part ESDR0502NMUTBG; LCSC C327480
U8: XC6220B331MR; SOT-23-5; Manufacturer Part XC6220B331MR-G‎; Digikey 893-1133-1-ND‎
U10: MAX17048; TDFN-8-1EP_2x2mm_P0.5mm_EP0.8x1.2mm; LCSC Part C2682616
U54: MCP73831-2-MC; DFN-8-1EP_3x2mm_P0.5mm_EP1.7x1.4mm
Y3: 32MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm; Manufacturer Part Q22FA1280001800; LCSC C2965584
Y4: 32.768 kHz; Crystal_SMD_2012-2Pin_2.0x1.2mm; Manufacturer Part SC20S-12.5PF20PPM; LCSC C99009

Connections of its further copies:
/Keymatrix_left/Col0: U4.A8 (AIN7/P0.31); also elsewhere on the board
/Keymatrix_left/Col1: U4.A10 (AIN5/P0.29); also elsewhere on the board
/Keymatrix_left/Col2: U4.A12 (AIN0/P0.02); also elsewhere on the board
/Keymatrix_left/Col3: U4.A14 (P1.15); also elsewhere on the board
/Keymatrix_left/Col4: U4.A16 (P1.13); also elsewhere on the board
/Keymatrix_left/Col5: U4.A20 (P1.10); also elsewhere on the board
/Keymatrix_left/Col6: U4.B19 (P1.11); also elsewhere on the board
/Keymatrix_left/LEDOut: Q2.3 (D); also elsewhere on the board
/Keymatrix_left/Row0: U4.AD16 (P0.20); also elsewhere on the board
/Keymatrix_left/Row1: U4.AD18 (P0.22); also elsewhere on the board
/Keymatrix_left/Row2: U4.AD20 (P0.24); also elsewhere on the board
/Keymatrix_left/Vcc: C64.2, U8.5 (VOUT); also elsewhere on the board
/nRF52840_left/ANT: AE2.1 (A), C25.2, R12.2
/nRF52840_left/BAT_I2C_SCL: U4.R1 (TRACEDATA3/P1.09), U10.7 (SCL)
/nRF52840_left/BAT_I2C_SDA: U4.N1 (P0.08), U10.8 (SDA)
/nRF52840_left/BAT_VOLT: C41.2, R14.2, R15.1, U4.U1 (TRACEDATA1/P0.12)
/nRF52840_left/BLUE_LED: D4.2 (A), U4.AD10 (P0.15)
/nRF52840_left/Backlight_trigger: Q2.1 (G), R40.2, U4.AD8 (P0.13)
/nRF52840_left/CAPS_LED: D23.2 (A), U4.AD12 (P0.17)
/nRF52840_left/CC1: P2.A5 (CC), R20.1
/nRF52840_left/CC2: P2.B5 (VCONN), R21.1
/nRF52840_left/MISO: U4.U24 (P1.04)
/nRF52840_left/MOSI: U4.W24 (P1.02)
/nRF52840_left/PPH_VCC_CTRL: R24.1, U4.L24 (NFC1/P0.09), U8.3 (CE)
/nRF52840_left/RESET: SW2.1, U4.AC9 (P0.14), U4.AC11 (P0.16), U4.AC13 (P0.18/~RESET)
/nRF52840_left/SCK: U4.R24 (P1.06)
/nRF52840_left/SCL: U4.J1 (AIN2/P0.04)
/nRF52840_left/SDA: U4.L1 (P0.06)
/nRF52840_left/SDA_RST: U4.G1 (P0.26)
/nRF52840_left/SWC: U4.AA24 (SWDCLK)
/nRF52840_left/SWD: U4.AC24 (SWDIO)
/nRF52840_left/SWO: U4.AD22 (TRACEDATA0/P1.00)
/nRF52840_left/USB_D+: P2.A6 (D+), P2.B6 (D+), U4.AD6 (D+), U5.5 (D+)
/nRF52840_left/USB_D-: P2.A7 (D-), P2.B7 (D-), U4.AD4 (D-), U5.6 (VBUS)
/nRF52840_left/VBAT: C39.2, C63.2, C66.2, C70.1, R13.1, TP7.1, U4.Y2 (VDDH), U8.1 (VIN), U10.2 (CELL), U10.3 (VDD), U54.3 (V_{BAT}), U54.4 (V_{BAT})
/nRF52840_left/VBUS: C34.2, D8.2 (A), P2.A4 (VBUS), P2.A9 (VBUS), P2.B4 (VBUS), P2.B9 (VBUS), U4.AD2 (VBUS), U5.4 (D-)
/nRF52840_left/VDD_NRF: C40.2, C42.2, C43.2, C44.2, C45.2, L8.1, U4.A22 (VDD), U4.AD14 (VDD), U4.AD23 (VDD), U4.B1 (VDD), U4.W1 (VDD)
/nRF52840_left/VSS_PA: C29.1, NT2.1, U4.F23 (VSS_PA)
/nRF52840_left/W_VBUS: C68.1, D8.1 (K), D10.2 (A), TP10.1, U54.1 (V_{DD}), U54.2 (V_{DD})
GND: C25.1, C26.1, C27.2, C28.2, C30.2, C31.2, C32.2, C33.2, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.2, C63.1, C64.1, C66.1, C68.2, C70.2, NT2.2, P2.A1 (GND), P2.A12 (GND), P2.B1 (GND), P2.B12 (GND), Q2.2 (S), R15.2, R16.1, R17.1, R20.2, R21.2, R24.2, R26.2, R32.1, R40.1, SW2.2, TP8.1, TP12.1, U4.B7 (VSS), U4.EP (VSS), U5.1 (GND), U8.2 (GND), U10.1 (CTG), U10.4 (GND), U10.6 (QSTRT), U10.9 (EP), U54.6 (V_{SS}), Y3.2, Y3.4; also elsewhere on the board
unnamed: C26.2, L5.1, R12.1
unnamed: D4.1 (K), R16.2
unnamed: D10.1 (K), R28.1
unnamed: D23.1 (K), R32.2
unnamed: L6.2, L7.1
unnamed: C46.1, P2.S1 (SHIELD), R17.2
unnamed: R13.2, R14.1
unnamed: C29.2, L5.2, U4.H23 (ANT)
unnamed: L7.2, U4.B3 (DCC)
unnamed: L8.2, U4.AB2 (DCCH)
unnamed: C30.1, U4.C1 (DEC1)
unnamed: C31.1, U4.D23 (DEC3)
unnamed: C35.2, C36.2, L6.1, U4.B5 (DEC4), U4.E24 (DEC6)
unnamed: C32.1, U4.N24 (DEC5)
unnamed: C33.1, U4.AC5 (DECUSB)
unnamed: C27.1, U4.B24 (XC1), Y3.1
unnamed: C28.1, U4.A23 (XC2), Y3.3
unnamed: C37.2, U4.D2 (XL1/P0.00), Y4.1
unnamed: C38.2, U4.F2 (XL2/P0.01), Y4.2
unnamed: R26.1, U54.8 (PROG)
unnamed: R28.2, U54.5 (STAT)

Notes on the sheet:
Battery Charger
V_{f} < 3.0V
Status LED
VBAT: 1000/10kR = 100mA
Key backlight
Battery Voltage Divider
C_{L} = 12.5pF
Battery Fuel Gauge
note: use internal pullups for these
Power
USB Connector + TVS
reference configuration 4
Decoupling Capacitors
C_{L} = 12pF

Parts:
C50, C58: C; C_0805_2012Metric
C51, C53, C54, C55, C56, C57, C59, C60, C61: C_Small; C_0402_1005Metric
C52: C_Small; C_0603_1608Metric
J50: Screw_Terminal_01x08; FPC_Connector; not fitted
R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R64, R65: R_Small; R_0402_1005Metric
R62, R63: R_Small; R_0603_1608Metric
U50: SSOP-32_6.1x11mm_P0.65mm
U51: MSOP-8_3x3mm_P0.65mm
U52: Trackpointer_4pin; not fitted
Y50: Crystal_GND2; Crystal_SMD 3pin

Connections:
/Keymatrix/Vcc: J50.1, R60.1; also elsewhere on the board
/Trackpointer/CLK: J50.8, U50.28; also elsewhere on the board
/Trackpointer/DATA: J50.2, U50.2; also elsewhere on the board
/Trackpointer/RST: C56.1, J50.3, U50.5; also elsewhere on the board
/Trackpointer/TP_A: C59.2, R59.1, R63.1, U52.13 (A)
/Trackpointer/TP_B: C60.2, R62.2, R64.1, U52.12 (B)
/Trackpointer/TP_D: C55.2, R51.2, R57.1, U50.21, U52.10 (D)
GND: C50.2, C51.1, C52.2, J50.7, R53.1, R61.1, R62.1, R63.2, U50.13, U51.4 (V-), U52.11 (C); also elsewhere on the board
unnamed: C50.1, U50.19
unnamed: C51.2, C53.2, C54.2, C58.2, R60.2, U50.14, U50.17, U50.26
unnamed: C52.1, R52.2, R55.2, U50.12
unnamed: C53.1, C54.1, C56.2, C58.1, R53.2, R61.2, U50.8, U50.32, Y50.2
unnamed: C55.1, C59.1, C60.1, R56.2
unnamed: R50.2, R52.1, U50.22
unnamed: R54.1, R55.1, R56.1, R57.2, R58.1, R65.1
unnamed: R54.2, U50.24
unnamed: U50.6, Y50.3
unnamed: U50.7, Y50.1
unnamed: C57.1, R58.2, U51.3 (+IN_A)
unnamed: C61.1, R65.2, U51.5 (+IN_B)
unnamed: C57.2, R59.2, U51.2 (-IN_A)
unnamed: C61.2, R64.2, U51.6 (-IN_B)
unnamed: U50.11, U51.1 (OUT_A)
unnamed: U50.10, U51.7 (OUT_B)
unnamed: R50.1, R51.1, U50.9, U50.20, U50.23, U51.8 (V+)

Board: 2 copper layers, 361 parts (189 on the bottom side), 209 nets.

## KiCad design pcb/pipar_sool/pipar_sool.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H15, H16, H17, H18: MountingHole; Kailh_socket_PG1350_reversible_Holes
Q1: AO3416 N-channel MOSFET; SOT-23; MPN AO3416; LCSC Part Number C479060
R39: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; Part Number PF1206FRF070R01L; JLCPCB ID C127703
SW1: PowerSwitch; SW_SPDT_PCM12
SW3: BUTTON-4P; SW4-SMD-2.8-2.6X1.6X0.53MM
TP1: BAT-; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP2: BAT+; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1, U2, U3, U4, U5: Solder Nut
U6, U9: Salt-smallest
U7: Seeeduino Xiao nRF52840; XIAO-nRF52840-Sense-14P-2.54-21X17.8MM
U10, U11, U12, U13, U14, U15: Fiducial_0.5mm_Mask1.5mm

Connections:
3V3: U7.10 (3V3); also elsewhere on the board
5V: U7.8 (5V); also elsewhere on the board
+4V: SW1.1 (B), U7.16 (BAT+); also elsewhere on the board
BAT+: SW1.2 (C), TP2.1; also elsewhere on the board
CLK: U7.20 (CLK); also elsewhere on the board
COL0: U7.7 (P1.11); also elsewhere on the board
COL1: U7.6 (P0.05); also elsewhere on the board
COL2: U7.5 (P0.04); also elsewhere on the board
COL3: U7.4 (P0.29); also elsewhere on the board
COL4: U7.3 (P0.28); also elsewhere on the board
COL5: U7.2 (P0.03); also elsewhere on the board
DIO: U7.19 (DIO); also elsewhere on the board
GND: Q1.2 (S), R39.1, SW3.2 (B0), SW3.4 (B1), TP1.1, U7.9 (GND), U7.15 (BAT-), U7.22 (GND); also elsewhere on the board
LEDOut: Q1.3 (D); also elsewhere on the board
LEDTrig: Q1.1 (G), R39.2, U7.11 (P1.15); also elsewhere on the board
PIN1: U7.1 (P0.02); also elsewhere on the board
ROW0: U7.14 (P1.12); also elsewhere on the board
ROW1: U7.13 (P1.13); also elsewhere on the board
ROW2: U7.12 (P1.14); also elsewhere on the board
RST: SW3.1 (A0), SW3.3 (A1), U7.21 (RST); also elsewhere on the board

Notes on the sheet:
LED Backlight
MCU Switches
MCU
Extras

Parts:
Q2: AO3416 N-channel MOSFET; SOT-23; MPN AO3416; LCSC Part Number C479060
R40: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; Part Number PF1206FRF070R01L; JLCPCB ID C127703
SW2: PowerSwitch; SW_SPDT_PCM12
SW4: BUTTON-4P; SW4-SMD-2.8-2.6X1.6X0.53MM
U8: Seeeduino Xiao nRF52840; XIAO-nRF52840-Sense-14P-2.54-21X17.8MM

Connections:
3V3: U8.10 (3V3); also elsewhere on the board
5V: U8.8 (5V); also elsewhere on the board
+4V: SW2.1 (B), U8.16 (BAT+); also elsewhere on the board
BAT+: SW2.2 (C); also elsewhere on the board
CLK: U8.20 (CLK); also elsewhere on the board
COL0: U8.7 (P1.11); also elsewhere on the board
COL1: U8.6 (P0.05); also elsewhere on the board
COL2: U8.5 (P0.04); also elsewhere on the board
COL3: U8.4 (P0.29); also elsewhere on the board
COL4: U8.3 (P0.28); also elsewhere on the board
COL5: U8.2 (P0.03); also elsewhere on the board
DIO: U8.19 (DIO); also elsewhere on the board
GND: Q2.2 (S), R40.1, SW4.2 (B0), SW4.4 (B1), U8.9 (GND), U8.15 (BAT-), U8.22 (GND); also elsewhere on the board
LEDOut: Q2.3 (D); also elsewhere on the board
LEDTrig: Q2.1 (G), R40.2, U8.11 (P1.15); also elsewhere on the board
PIN1: U8.1 (P0.02); also elsewhere on the board
ROW0: U8.14 (P1.12); also elsewhere on the board
ROW1: U8.13 (P1.13); also elsewhere on the board
ROW2: U8.12 (P1.14); also elsewhere on the board
RST: SW4.1 (A0), SW4.3 (A1), U8.21 (RST); also elsewhere on the board
