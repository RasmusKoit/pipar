# Repository RasmusKoit/pipar (continued)

## KiCad design pcb/pipar_point_v3/pipar_point_v3.kicad_pcb (continued)

Parts:
D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: D_Small; D_SOD-523; Mouser Part Number 621-1N4148WT
H28, H29, H30, H31, H32, H33, H34, H35, H36, H37, H38, H39, H40, H41, H42, H43, H44, H45, H46, H47: SwitchHoles; SwitchHoles_Kailh_Choc_V1
KHS1, KHS2, KHS3, KHS4, KHS5, KHS6, KHS7, KHS8, KHS9, KHS10, KHS11, KHS12, KHS13, KHS14, KHS15, KHS16, KHS17, KHS18, KHS19, KHS20: KHS; Kailh_HS_Socket
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20: LED_Small; LED_0603_1608Metric; Mouser Part Number 743-IN-S63AT5UW
Q1: AO3400A; SOT-23; Manufacturer_Part_Number SI2342DS-T1-GE3; Mouser Part Number 78-SI2342DS-T1-GE3
R8: 5.1k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-075K1L; Mouser Part Number 603-RC0603FR-075K1L
R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28: 49.9R; R_0603_1608Metric; Manufacturer_Part_Number AC0603FR-0749R9L; Mouser Part Number 603-AC0603FR-0749R9L

Connections:
/Side-Left/3.3V: R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2; also elsewhere on the board
/Side-Left/Backlight: Q1.1 (G), R8.2; also elsewhere on the board
/Side-Left/Col0: KHS1.1, KHS2.1, KHS3.1; also elsewhere on the board
/Side-Left/Col1: KHS4.1, KHS5.1, KHS6.1; also elsewhere on the board
/Side-Left/Col2: KHS7.1, KHS8.1, KHS9.1; also elsewhere on the board
/Side-Left/Col3: KHS10.1, KHS11.1, KHS12.1; also elsewhere on the board
/Side-Left/Col4: KHS13.1, KHS14.1, KHS15.1; also elsewhere on the board
/Side-Left/Col5: KHS16.1, KHS17.1, KHS18.1; also elsewhere on the board
/Side-Left/Col6: KHS19.1, KHS20.1; also elsewhere on the board
/Side-Left/Key Matrix/LEDOut: LED1.1 (K), LED2.1 (K), LED3.1 (K), LED4.1 (K), LED5.1 (K), LED6.1 (K), LED7.1 (K), LED8.1 (K), LED9.1 (K), LED10.1 (K), LED11.1 (K), LED12.1 (K), LED13.1 (K), LED14.1 (K), LED15.1 (K), LED16.1 (K), LED17.1 (K), LED18.1 (K), LED19.1 (K), LED20.1 (K), Q1.3 (D)
/Side-Left/Row0: D5.1 (K), D8.1 (K), D11.1 (K), D14.1 (K), D17.1 (K), D20.1 (K); also elsewhere on the board
/Side-Left/Row1: D6.1 (K), D9.1 (K), D12.1 (K), D15.1 (K), D18.1 (K), D21.1 (K), D23.1 (K); also elsewhere on the board
/Side-Left/Row2: D7.1 (K), D10.1 (K), D13.1 (K), D16.1 (K), D19.1 (K), D22.1 (K), D24.1 (K); also elsewhere on the board
GND: Q1.2 (S), R8.1; also elsewhere on the board
unnamed: D5.2 (A), KHS1.2
unnamed: D6.2 (A), KHS2.2
unnamed: D7.2 (A), KHS3.2
unnamed: D8.2 (A), KHS4.2
unnamed: D9.2 (A), KHS5.2
unnamed: D10.2 (A), KHS6.2
unnamed: D11.2 (A), KHS7.2
unnamed: D12.2 (A), KHS8.2
unnamed: D13.2 (A), KHS9.2
unnamed: D14.2 (A), KHS10.2
unnamed: D15.2 (A), KHS11.2
unnamed: D16.2 (A), KHS12.2
unnamed: D17.2 (A), KHS13.2
unnamed: D18.2 (A), KHS14.2
unnamed: D19.2 (A), KHS15.2
unnamed: D20.2 (A), KHS16.2
unnamed: D21.2 (A), KHS17.2
unnamed: D22.2 (A), KHS18.2
unnamed: D23.2 (A), KHS19.2
unnamed: D24.2 (A), KHS20.2
unnamed: LED1.2 (A), R9.1
unnamed: LED2.2 (A), R10.1
unnamed: LED3.2 (A), R11.1
unnamed: LED4.2 (A), R12.1
unnamed: LED5.2 (A), R13.1
unnamed: LED6.2 (A), R14.1
unnamed: LED7.2 (A), R15.1
unnamed: LED8.2 (A), R16.1
unnamed: LED9.2 (A), R17.1
unnamed: LED10.2 (A), R18.1
unnamed: LED11.2 (A), R19.1
unnamed: LED12.2 (A), R20.1
unnamed: LED13.2 (A), R21.1
unnamed: LED14.2 (A), R22.1
unnamed: LED15.2 (A), R23.1
unnamed: LED16.2 (A), R24.1
unnamed: LED17.2 (A), R25.1
unnamed: LED18.2 (A), R26.1
unnamed: LED19.2 (A), R27.1
unnamed: LED20.2 (A), R28.1

Parts of its further copies:
D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52: D_Small; D_SOD-523; Mouser Part Number 621-1N4148WT
H54, H55, H56, H57, H58, H59, H60, H61, H62, H63, H64, H65, H66, H67, H68, H69, H70, H71, H72, H73: SwitchHoles; SwitchHoles_Kailh_Choc_V1
KHS21, KHS22, KHS23, KHS24, KHS25, KHS26, KHS27, KHS28, KHS29, KHS30, KHS31, KHS32, KHS33, KHS34, KHS35, KHS36, KHS37, KHS38, KHS39, KHS40: KHS; Kailh_HS_Socket
LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40: LED_Small; LED_0603_1608Metric; Mouser Part Number 743-IN-S63AT5UW
Q2: AO3400A; SOT-23; Manufacturer_Part_Number SI2342DS-T1-GE3; Mouser Part Number 78-SI2342DS-T1-GE3
R46: 5.1k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-075K1L; Mouser Part Number 603-RC0603FR-075K1L
R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66: 49.9R; R_0603_1608Metric; Manufacturer_Part_Number AC0603FR-0749R9L; Mouser Part Number 603-AC0603FR-0749R9L

Connections of its further copies:
/Side-Right/3.3V: R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2; also elsewhere on the board
/Side-Right/Backlight: Q2.1 (G), R46.2; also elsewhere on the board
/Side-Right/Col0: KHS21.1, KHS22.1, KHS23.1; also elsewhere on the board
/Side-Right/Col1: KHS24.1, KHS25.1, KHS26.1; also elsewhere on the board
/Side-Right/Col2: KHS27.1, KHS28.1, KHS29.1; also elsewhere on the board
/Side-Right/Col3: KHS30.1, KHS31.1, KHS32.1; also elsewhere on the board
/Side-Right/Col4: KHS33.1, KHS34.1, KHS35.1; also elsewhere on the board
/Side-Right/Col5: KHS36.1, KHS37.1, KHS38.1; also elsewhere on the board
/Side-Right/Col6: KHS39.1, KHS40.1; also elsewhere on the board
/Side-Right/Key Matrix/LEDOut: LED21.1 (K), LED22.1 (K), LED23.1 (K), LED24.1 (K), LED25.1 (K), LED26.1 (K), LED27.1 (K), LED28.1 (K), LED29.1 (K), LED30.1 (K), LED31.1 (K), LED32.1 (K), LED33.1 (K), LED34.1 (K), LED35.1 (K), LED36.1 (K), LED37.1 (K), LED38.1 (K), LED39.1 (K), LED40.1 (K), Q2.3 (D)
/Side-Right/Row0: D33.1 (K), D36.1 (K), D39.1 (K), D42.1 (K), D45.1 (K), D48.1 (K); also elsewhere on the board
/Side-Right/Row1: D34.1 (K), D37.1 (K), D40.1 (K), D43.1 (K), D46.1 (K), D49.1 (K), D51.1 (K); also elsewhere on the board
/Side-Right/Row2: D35.1 (K), D38.1 (K), D41.1 (K), D44.1 (K), D47.1 (K), D50.1 (K), D52.1 (K); also elsewhere on the board
GND: Q2.2 (S), R46.1; also elsewhere on the board
unnamed: D33.2 (A), KHS21.2
unnamed: D34.2 (A), KHS22.2
unnamed: D35.2 (A), KHS23.2
unnamed: D36.2 (A), KHS24.2
unnamed: D37.2 (A), KHS25.2
unnamed: D38.2 (A), KHS26.2
unnamed: D39.2 (A), KHS27.2
unnamed: D40.2 (A), KHS28.2
unnamed: D41.2 (A), KHS29.2
unnamed: D42.2 (A), KHS30.2
unnamed: D43.2 (A), KHS31.2
unnamed: D44.2 (A), KHS32.2
unnamed: D45.2 (A), KHS33.2
unnamed: D46.2 (A), KHS34.2
unnamed: D47.2 (A), KHS35.2
unnamed: D48.2 (A), KHS36.2
unnamed: D49.2 (A), KHS37.2
unnamed: D50.2 (A), KHS38.2
unnamed: D51.2 (A), KHS39.2
unnamed: D52.2 (A), KHS40.2
unnamed: LED21.2 (A), R47.1
unnamed: LED22.2 (A), R48.1
unnamed: LED23.2 (A), R49.1
unnamed: LED24.2 (A), R50.1
unnamed: LED25.2 (A), R51.1
unnamed: LED26.2 (A), R52.1
unnamed: LED27.2 (A), R53.1
unnamed: LED28.2 (A), R54.1
unnamed: LED29.2 (A), R55.1
unnamed: LED30.2 (A), R56.1
unnamed: LED31.2 (A), R57.1
unnamed: LED32.2 (A), R58.1
unnamed: LED33.2 (A), R59.1
unnamed: LED34.2 (A), R60.1
unnamed: LED35.2 (A), R61.1
unnamed: LED36.2 (A), R62.1
unnamed: LED37.2 (A), R63.1
unnamed: LED38.2 (A), R64.1
unnamed: LED39.2 (A), R65.1
unnamed: LED40.2 (A), R66.1

Notes on the sheet:
Key
Ring
Index
OuterIndex
Pinkie
OuterPinkie
Thumbs
Middle

Board: 4 copper layers, 356.4 x 122.8 mm, 351 parts (12 on the bottom side), 209 nets.

## KiCad design pcb/pipar_urchin_unibody/pipar_urchin_unibody.kicad_pcb

Parts:
C1, C6, C7: 1uF; C_0603_1608Metric; Mouser Part Number 963-LMK107B7105KA-T
C2: 10nF; C_0603_1608Metric; Mouser Part Number 810-CGA3E2X7R1H103K
C3: 100nF; C_0603_1608Metric; Mouser Part Number 603-CC603KRX7R8BB104
C4, C5, C8: 10uF; C_0603_1608Metric; Mouser Part Number 81-GRM188R61E106KA3J
C9: 2.2uF; C_0603_1608Metric; Mouser Part Number 963-EMK107BB7225KA-T
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36: D_Small; D_SOD-123; Mouser Part Number 241-1N4148W_R1_00001
D37: LED_Error; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5A; Mouser Part Number 743-IN-S63AT5A
D38: LED_Green; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5G; Mouser Part Number 743-IN-S63AT5G
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad
J1: Conn_02x03_Odd_Even; PinHeader_2x03_P2.00mm_Vertical
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; Mouser Part Number 179-UJ20CHGSMTP16TR
J3: Conn_01x02; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal; Mouser Part Number 306-S2BPHSM4TBLFSN
J4: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
KHS1, KHS2, KHS3, KHS4, KHS5, KHS6, KHS7, KHS8, KHS9, KHS10, KHS11, KHS12, KHS13, KHS14, KHS15, KHS16, KHS17, KHS18, KHS19, KHS20, KHS21, KHS22, KHS23, KHS24, KHS25, KHS26, KHS27, KHS28, KHS29, KHS30, KHS31, KHS32, KHS33, KHS34, KHS35, KHS36: KHS; CPG1316S01D02_castelated_mikecinq
L1: 2.2uH; L_0805_2012Metric; Manufacturer_Part_Number MLZ2012A2R2WT000; Mouser Part Number 810-MLZ2012A2R2WT000
LED1: LED_Blue; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5B; Mouser Part Number 743-S63AT5B
LED2: LED_Green; LED_0603_1608Metric; Manufacturer_Part_Number IN-S63AT5G; Mouser Part Number 743-IN-S63AT5G
NT1: NetTie_2; NetTie-2_THT_Pad0.3mm
R1, R2, R3, R4: 1.5k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-071K5L; Mouser Part Number 603-RC0603FR-071K5L
R5, R6: 10k; R_0603_1608Metric; Manufacturer_Part_Number CRCW060310K0FKEA; Mouser Part Number 71-CRCW0603-10K-E3
R7: 500k; R_0603_1608Metric; Manufacturer_Part_Number CRCW0603499KFKEA; Mouser Part Number 71-CRCW0603-499K-E3
SW1: EVP-BB1AAB000; EVPBB2A9B000; Mouser Part Number 667-EVP-BB1AAB000
SW2: SW_SPDT; SW_SPDT_PCM12; Manufacturer_Part_Number PCM12SMTBR; Mouser Part Number 611-PCM12SMTBR
TP1, TP2, TP3: TestPoint_Probe; TestPoint_Pad_D1.0mm
U1: ISP1807-LR-RS; Manufacturer_Part_Number ISP1807-LR-RS; Mouser Part Number 359-ISP1807-LR-RS
U2: ESDR0502NMUTAG; UDFN-6_1.2x1.0mm_P0.4mm; Manufacturer Part ESDR0502NMUTBG; LCSC C327480
U3: nPM1300-QEXX; QFN-32-1EP_5x5mm_P0.5mm_EP3.6x3.6mm_ThermalVias; Manufacturer_Part_Number nPM1300-QEAA-R7; Mouser Part Number 949-NPM1300-QEAA-R7

Connections:
/3.3V: C3.2, C8.2, J1.1, J4.2, L1.1, R1.1, R2.1, R5.1, R6.1, TP3.1, U1.26 (VCC_NRF), U3.12 (VDDIO), U3.32 (VOUT2)
/BAT_SCL: R6.2, U1.34 (P0_06), U3.14 (SCL)
/BAT_SDA: R5.2, U1.32 (P0_08), U3.13 (SDA)
/CC1: J2.A5 (CC1), U3.23 (CC1)
/CC2: J2.B5 (CC2), U3.24 (CC2)
/Col0: KHS1.1, KHS7.1, KHS13.1, U1.48 (P0_28_AIN4)
/Col1: KHS2.1, KHS8.1, KHS14.1, U1.46 (P0_29_AIN5)
/Col2: KHS3.1, KHS9.1, KHS15.1, U1.44 (P0_30_AIN6)
/Col3: KHS4.1, KHS10.1, KHS16.1, U1.42 (P0_31_AIN7)
/Col4: KHS5.1, KHS11.1, KHS17.1, U1.40 (P0_02_AIN0)
/Col5: KHS6.1, KHS12.1, KHS18.1, U1.38 (P0_03_AIN1)
/Col6: KHS19.1, KHS25.1, KHS31.1, U1.36 (P0_05_AIN3)
/Col7: KHS20.1, KHS26.1, KHS32.1, U1.47 (P0_23)
/Col8: KHS21.1, KHS27.1, KHS33.1, U1.45 (P0_19)
/Col9: KHS22.1, KHS28.1, KHS34.1, U1.43 (P0_11_TRACEDATA)
/Col10: KHS23.1, KHS29.1, KHS35.1, U1.41 (P0_25)
/Col11: KHS24.1, KHS30.1, KHS36.1, U1.39 (P0_27)
/LED_1: LED1.1 (K), U1.52 (P1_14)
/LED_2: LED2.1 (K), U1.59 (P1_12)
/PVSS2: C4.1, C8.1, NT1.1, U3.6 (PVSS2)
/RESET: J1.6, SW1.1 (NO_1), SW1.2 (NO_2), U1.13 (P0_18_RESET)
/Row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.56 (P1_09_TRACEDATA3)
/Row1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), U1.63 (P1_04)
/Row2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.9 (P0_16)
/SCL: J4.3, U1.35 (P0_04_AIN2)
/SDA: J4.4, U1.33 (P0_07_TRACECLK)
/SWDCLK: J1.4, U1.30 (SWDCLK)
/SWDIO: J1.2, U1.28 (SWDIO)
/USB_D+: J2.A6 (D+), J2.B6 (D+), U1.8 (D+), U2.2 (NC), U2.5 (D+)
/USB_D-: J2.A7 (D-), J2.B7 (D-), U1.10 (D-), U2.3 (NC), U2.4 (D-)
/VBAT: C9.1, SW2.3 (C), U3.19 (VBAT)
/VBUS: C1.1, C6.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U2.6 (VBUS), U3.21 (VBUS)
/VBUSOut: C7.1, TP2.1, U1.12 (VBUS), U3.22 (VBUSOUT)
/VSYS: C4.2, C5.2, R3.2, R4.2, U3.1 (VOUT1), U3.4 (PVDD), U3.20 (VSYS)
GND: C1.2, C2.2, C3.1, C5.1, C6.2, C7.2, C9.2, H1.1, H2.1, H3.1, H4.1, J1.3, J1.5, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J3.1, J4.1, NT1.2, R7.2, SW1.3 (COM_1), SW1.4 (COM_2), TP1.1, U1.1 (VSS), U1.7 (VSS), U1.14 (VSS), U1.16 (VSS), U1.18 (VSS), U1.21 (VSS), U1.23 (VSS), U1.24 (VSS), U1.25 (VSS), U1.31 (VSS), U2.1 (GND), U3.2 (PVSS1), U3.17 (VSET1), U3.18 (NTC), U3.28 (LSIN1/VINLDO1), U3.29 (LSOUT1/VOUTLDO1), U3.30 (LSIN2/VINLDO2), U3.31 (LSOUT2/VOUTLDO2), U3.33 (AVSS)
unnamed: D1.2 (A), KHS1.2
unnamed: D2.2 (A), KHS2.2
unnamed: D3.2 (A), KHS3.2
unnamed: D4.2 (A), KHS4.2
unnamed: D5.2 (A), KHS5.2
unnamed: D6.2 (A), KHS6.2
unnamed: D7.2 (A), KHS7.2
unnamed: D8.2 (A), KHS8.2
unnamed: D9.2 (A), KHS9.2
unnamed: D10.2 (A), KHS10.2
unnamed: D11.2 (A), KHS11.2
unnamed: D12.2 (A), KHS12.2
unnamed: D13.2 (A), KHS13.2
unnamed: D14.2 (A), KHS14.2
unnamed: D15.2 (A), KHS15.2
unnamed: D16.2 (A), KHS16.2
unnamed: D17.2 (A), KHS17.2
unnamed: D18.2 (A), KHS18.2
unnamed: D19.2 (A), KHS19.2
unnamed: D20.2 (A), KHS20.2
unnamed: D21.2 (A), KHS21.2
unnamed: D22.2 (A), KHS22.2
unnamed: D23.2 (A), KHS23.2
unnamed: D24.2 (A), KHS24.2
unnamed: D25.2 (A), KHS25.2
unnamed: D26.2 (A), KHS26.2
unnamed: D27.2 (A), KHS27.2
unnamed: D28.2 (A), KHS28.2
unnamed: D29.2 (A), KHS29.2
unnamed: D30.2 (A), KHS30.2
unnamed: D31.2 (A), KHS31.2
unnamed: D32.2 (A), KHS32.2
unnamed: D33.2 (A), KHS33.2
unnamed: D34.2 (A), KHS34.2
unnamed: D35.2 (A), KHS35.2
unnamed: D36.2 (A), KHS36.2
unnamed: D37.2 (A), R3.1
unnamed: D37.1 (K), U3.25 (LED0)
unnamed: D38.2 (A), R4.1
unnamed: D38.1 (K), U3.26 (LED1)
unnamed: C2.1, J2.S1 (SHIELD)
unnamed: J3.2, SW2.2 (B)
unnamed: LED1.2 (A), R1.2
unnamed: LED2.2 (A), R2.2
unnamed: U1.20 (OUT_ANT), U1.22 (OUT_MOD)
unnamed: L1.2, U3.5 (SW2)
unnamed: R7.1, U3.16 (VSET2)

Notes on the sheet:
Index
Status LED
Ring
Key
Middle
V_{f} < 3.0V
BMIC + Power
USB Connector + ESD
Pinkie
Thumbs
OuterIndex
VIA to GND

Board: 2 copper layers, 223.5 x 112.5 mm, 110 parts (3 on the bottom side), 82 nets.

## KiCad design pcb/pipar_chip/pipar_chip.kicad_pcb

Parts:
C1: 10nF; C_0603_1608Metric; Mouser Part Number 810-C1608X5R1H103KAA
C2, C3, C4: 10uF; C_0603_1608Metric; Mouser Part Number 810-C1608X5R0J106K
C5: 2.2uF; C_0603_1608Metric; Mouser Part Number 810-C1608X5R1E225M
C6, C7, C8: 1uF; C_0603_1608Metric; Mouser Part Number 603-CC603KRX7R5BB105
D1, D4: LED_Small; LED_0603_1608Metric; Manufacturer_Part_Number IN-PIS63BTPG; Mouser Part Number 743-IN-PIS63BTPG
D2: LED_Small; LED_0603_1608Metric; Manufacturer_Part_Number IN-PIS63BTPB; Mouser Part Number 743-IN-PIS63BTPB
D3, D18: LED_Small; LED_0603_1608Metric; Manufacturer_Part_Number IN-PIS63BTPR; Mouser Part Number 743-IN-PIS63BTPR
FID1, FID2, FID3: Fiducial; Fiducial_0.5mm_Mask1mm
H1, H2, H3, H4: MountingHole; SMTSO_M2_C4_2+C2.7_1.5
H5: MountingHole; chip
H6: MountingHole; Salt-smallest
IC1: MCP1700T-3302E_MAY; SON65P200X200X90-7N; Manufacturer_Part_Number MCP1700T-3302E/MAY; Mouser Part Number 579-MCP1700T3302EMAY
J1: Conn_02x03_Odd_Even; PinHeader_2x03_P1.00mm_Vertical
J2: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; Manufacturer_Part_Number UJ20-C-H-G-SMT-P16-TR; Mouser Part Number 179-UJ20CHGSMTP16TR
L1: 2.2uH; L_0805_2012Metric; Manufacturer_Part_Number MLZ2012A2R2WT000; Mouser Part Number 810-MLZ2012A2R2WT000
R1, R2, R3, R6: 1.5k; R_0603_1608Metric; Manufacturer_Part_Number RC0603FR-071K5L; Mouser Part Number 603-RC0603FR-071K5L
R4, R5, R9, R12: 5.1k; R_0603_1608Metric; Manufacturer_Part_Number 603-RC0603FR-075K1L; Mouser Part Number 603-RC0603FR-075K1L
SW1: EVP-BB1AAB000; EVPBB2A9B000; Mouser Part Number 667-EVP-BB1AAB000
SW2: SW_SPDT; SW_SPDT_PCM12; Manufacturer_Part_Number PCM12SMTBR; Mouser Part Number 611-PCM12SMTBR
TP1: TestPoint; TestPoint_Pad_D1.5mm
TP2: TestPoint; TestPoint_Pad_1.5x1.5mm
TP3, TP4, TP5, TP6, TP7, TP8: TestPoint_Probe; TestPoint_Pad_D1.0mm
U1: ESDR0502NMUTAG; UDFN-6_1.2x1.0mm_P0.4mm; Manufacturer Part ESDR0502NMUTBG; LCSC C327480
U2: nPM1100-QDXX; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_ThermalVias; Manufacturer_Part_Number NPM1100-QDAA-R; Mouser Part Number 949-NPM1100-QDAA-R
U3: ISP1807-LR-RS; Manufacturer_Part_Number ISP1807-LR-RS; Mouser Part Number 359-ISP1807-LR-RS

Connections:
/3.3VOUT: C6.2, IC1.6 (VOUT), TP3.1; also elsewhere on the board
/3VOUT: C2.2, J1.1, L1.1, TP5.1, U2.1 (VOUTB), U3.26 (VCC_NRF)
/Backlight_trigger: U3.56 (P1_09_TRACEDATA3); also elsewhere on the board
/CC1: J2.A5 (CC1), R12.1
/CC2: J2.B5 (CC2), R4.1
/Col0: U3.52 (P1_14); also elsewhere on the board
/Col1: U3.53 (P1_13); also elsewhere on the board
/Col2: U3.54 (P1_05); also elsewhere on the board
/Col3: U3.55 (P1_08); also elsewhere on the board
/LChg: D4.1 (K), U2.8 (CHG)
/LED_1: D18.2 (A), U3.57 (P1_00_TRACEDATA0)
/LED_2: D1.2 (A), U3.58 (P1_03)
/LED_3: D2.2 (A), U3.59 (P1_12)
/LError: D3.1 (K), U2.10 (ERR)
/RESET: J1.6, SW1.1 (NO_1), SW1.2 (NO_2), U3.13 (P0_18_RESET)
/Row0: U3.49 (P1_02); also elsewhere on the board
/Row1: U3.50 (P1_06); also elsewhere on the board
/Row2: U3.51 (P1_15); also elsewhere on the board
/SWDCLK: J1.4, U3.30 (SWDCLK)
/SWDIO: J1.2, U3.28 (SWDIO)
/USB_D+: J2.A6 (D+), J2.B6 (D+), U1.5 (D+), U2.20 (D+), U3.8 (D+)
/USB_D-: J2.A7 (D-), J2.B7 (D-), U1.4 (D-), U2.19 (D-), U3.10 (D-)
/VBAT: C8.1, SW2.3 (C), U2.15 (VBAT)
/VBUS: C5.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), TP6.1, TP8.1, U1.6 (VBUS), U2.17 (VBUS), U3.12 (VBUS)
/VSYS: C4.2, C7.2, D3.2 (A), D4.2 (A), IC1.1 (VIN), TP4.1, U2.2 (VOUTBSET1), U2.3 (VOUTBSET0), U2.5 (ISET), U2.16 (VSYS)
GND: C1.2, C2.1, C3.1, C4.1, C5.2, C6.1, C7.1, C8.2, IC1.3 (GND), IC1.7 (EP), J1.3, J1.5, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), R1.1, R2.1, R3.1, R4.2, R5.1, R6.1, R12.2, SW1.3 (COM_1), SW1.4 (COM_2), TP2.1, TP7.1, U1.1 (GND), U2.4 (AVSS), U2.6 (SHPACT), U2.7 (MODE), U2.9 (VTERMSET), U2.11 (SHPHLD), U2.23 (PVSS), U2.25 (AVSS), U3.1 (VSS), U3.7 (VSS), U3.14 (VSS), U3.16 (VSS), U3.18 (VSS), U3.21 (VSS), U3.23 (VSS), U3.24 (VSS), U3.25 (VSS), U3.31 (VSS); also elsewhere on the board
unnamed: D1.1 (K), R2.2
unnamed: D2.1 (K), R3.2
unnamed: D18.1 (K), R1.2
unnamed: C1.1, J2.S1 (SHIELD)
unnamed: R5.2, R9.1
unnamed: SW2.2 (B), TP1.1
unnamed: C3.2, U2.21 (DEC)
unnamed: R6.2, U2.12 (ICHG)
unnamed: R9.2, U2.14 (NTC)
unnamed: L1.2, U2.22 (SW)
unnamed: U3.20 (OUT_ANT), U3.22 (OUT_MOD)

Notes on the sheet:
USB Connector + ESD
V_{f} < 3.0V
Status LED
BMIC + Power
